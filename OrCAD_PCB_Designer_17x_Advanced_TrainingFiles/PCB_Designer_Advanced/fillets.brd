# Allegro board fillets.brd (continued)
## Nets (continued)
DATA2+: U1.B5 U2.D6
DATA2-: U1.A5 U2.C6
DATA3+: U1.D5 U2.B6
DATA3-: U1.C5 U2.A6
DATA.BA0: U1.H16 U6.13 U8.2 U9.13
DATA.BA1: U1.H15 U6.14 U8.3 U9.14
DATA.BA2: U1.G14 U6.16 U8.5 U9.16
DATA.BA3: U1.G16 U6.17 U8.6 U9.17
DATA.BD0: U1.F16 U9.2
DATA.BD1: U1.F15 U9.3
DATA.BD2: U1.E16 U9.5
DATA.BD3: U1.E15 U9.6
DATA.BD4: U1.E13 U9.8
DATA.BD5: U1.E12 U9.9
DATA.BD6: U1.B15 U9.11
DATA.BD7: U1.B16 U9.12
DATA.BD8: U1.F12 U6.2 U8.23
DATA.BD9: U1.G11 U6.3 U8.22
DATA.BD12: U1.F13 U6.8 U8.17
DATA.BD13: U1.F14 U6.9 U8.16
DATA.BD14: U1.C15 U6.11 U8.14
DATA.BD15: U1.C16 U6.12 U8.13
DATA.CLKB: J6.E16 U1.J16
DDIR: U6.1 U7.1 U8.24 U9.1
DDR_A0: U2.C1 U12.M8 U13.M8
DDR_A1: U2.D1 U12.M3 U13.M3
DDR_A2: U2.E1 U12.M7 U13.M7
DDR_A3: U2.F1 U12.N2 U13.N2
DDR_A4: U2.G1 U12.N8 U13.N8
DDR_A5: U2.H1 U12.N3 U13.N3
DDR_A6: U2.J1 U12.N7 U13.N7
DDR_A7: U2.K1 U12.P2 U13.P2
DDR_A8: U2.L1 U12.P8 U13.P8
DDR_A9: U2.M1 U12.P3 U13.P3
DDR_A10: U2.N1 U12.M2 U13.M2
DDR_A11: U2.P1 U12.P7 U13.P7
DDR_A12: U2.R1 U12.R2 U13.R2
DDR_BA0: U2.M2 U12.L2 U13.L1
DDR_BA1: U2.P2 U12.L3 U13.L3
DDR_BA2: U2.R2 U12.L1 U13.L2
DDR_DQ0: U2.F5 U12.G8
DDR_DQ1: U2.C2 U12.G2
DDR_DQ2: U2.F4 U12.H7
DDR_DQ3: U2.E4 U12.H3
DDR_DQ4: U2.D3 U12.H1
DDR_DQ5: U2.G5 U12.H9
DDR_DQ6: U2.C3 U12.F1
DDR_DQ7: U2.G3 U12.F9
DDR_DQ8: U2.E2 U12.C8
DDR_DQ9: U2.B3 U12.C2
DDR_DQ10: U2.F3 U12.D7
DDR_DQ11: U2.B1 U12.D3
DDR_DQ12: U2.B2 U12.D1
DDR_DQ13: U2.F2 U12.D9
DDR_DQ14: U2.A2 U12.B1
DDR_DQ15: U2.E3 U12.B9
DDR_DQ16: U2.L3 U13.G8
DDR_DQ17: U2.H5 U13.G2
DDR_DQ18: U2.K5 U13.H7
DDR_DQ19: U2.K2 U13.H3
DDR_DQ20: U2.H3 U13.H1
DDR_DQ21: U2.L5 U13.H9
DDR_DQ22: U2.H2 U13.F1
DDR_DQ23: U2.M4 U13.F9
DDR_DQ24: U2.M5 U13.C8
DDR_DQ25: U2.J3 U13.C2
DDR_DQ26: U2.L4 U13.D7
DDR_DQ27: U2.K3 U13.D3
DDR_DQ28: U2.H4 U13.D1
DDR_DQ29: U2.N3 U13.D9
DDR_DQ30: U2.J4 U13.B1
DDR_DQ31: U2.N4 U13.B9
DDS.DATA0: U2.B10 U4.4
DDS.DATA1: U2.C10 U4.3
DDS.DATA2: U2.E10 U4.2
DDS.DATA3: U2.F10 U4.1
DDS.DATA4: U2.E11 U4.28
DDS.DATA5: U2.D11 U4.27
DDS.DATA6: U2.C11 U4.26
DDS.DATA7: U2.A11 U4.25
DDS.FQUD: U2.B12 U4.8
DDS.RESET: U2.A13 U4.22
DDS.WCLK: U2.A14 U4.7
DDS_CLK: L4.2 U4.9
DDS_OUT: C34.2 C36.2 L5.1 U4.20
DEN/: U6.48 U7.17 U9.48
DHEN/: U7.18 U8.25(G\)
DI: P1.7 U1.C12
DIFF1+: U1.D16 U6.5 U8.20
DIFF1-: U1.D14 U6.6 U8.19
DQ0: U32.19 U38.12
DQ1: U32.18 U38.13
DQ2: U32.17 U38.14
DQ3: U32.16 U38.15
DQ4: U32.15 U38.16
DQ5: U32.14 U38.17
DQ6: U32.13 U38.18
DQ7: U32.12 U38.19
DQ8: U35.19 U39.12
DQ9: U35.18 U39.13
DQ10: U35.17 U39.14
DQ11: U35.16 U39.15
DQ12: U35.15 U39.16
DQ13: U35.14 U39.17
DQ14: U35.13 U39.18
DQ15: U35.12 U39.19
FPGA/: U7.15 U48.5
GAIN: U1.J4 U33.6 U36.6
HS/: U7.16 U48.4
JTAG_D0: P1.8 U2.E14
LED1: Q4.1 R31.2
LED2: Q5.1 R32.2
LED3: Q6.1 R33.2
LED4: Q7.1 R34.2
LPF_OUT: C42.1 R17.2 R18.2
MEMORY.CTRL.RCS0: J7.26 U1.J1 U40.22 U44.22
MEMORY.CTRL.RCS1: J7.76 U1.G3 U41.22 U45.22
MEMORY.CTRL.RCS2: J7.126 U1.F2 U42.22 U46.22
MEMORY.CTRL.RCS3: J7.176 U1.G6 U43.22 U47.22
MEMORY.CTRL.RWE: J7.27 J7.77 J7.127 J7.177 U1.M11 U40.29(W\E\) U41.29(W\E\) U42.29(W\E\) U43.29(W\E\) U44.29(W\E\) U45.29(W\E\) U46.29(W\E\) U47.29(W\E\)
MEMORY.RA0: J7.1 J7.51 J7.101 J7.151 U1.P5 U40.12 U41.12 U42.12 U43.12 U44.12 U45.12 U46.12 U47.12
MEMORY.RA1: J7.2 J7.52 J7.102 J7.152 U1.P10 U40.11 U41.11 U42.11 U43.11 U44.11 U45.11 U46.11 U47.11
MEMORY.RA2: J7.3 J7.53 J7.103 J7.153 U1.N11 U40.10 U41.10 U42.10 U43.10 U44.10 U45.10 U46.10 U47.10
MEMORY.RA3: J7.4 J7.54 J7.104 J7.154 U1.R9 U40.9 U41.9 U42.9 U43.9 U44.9 U45.9 U46.9 U47.9
MEMORY.RA4: J7.5 J7.55 J7.105 J7.155 U1.P8 U40.8 U41.8 U42.8 U43.8 U44.8 U45.8 U46.8 U47.8
MEMORY.RA5: J7.6 J7.56 J7.106 J7.156 U1.R7 U40.7 U41.7 U42.7 U43.7 U44.7 U45.7 U46.7 U47.7
MEMORY.RA6: J7.7 J7.57 J7.107 J7.157 U1.P6 U40.6 U41.6 U42.6 U43.6 U44.6 U45.6 U46.6 U47.6
MEMORY.RA7: J7.8 J7.58 J7.108 J7.158 U1.N5 U40.5 U41.5 U42.5 U43.5 U44.5 U45.5 U46.5 U47.5
MEMORY.RA8: J7.9 J7.59 J7.109 J7.159 U1.L8 U40.27 U41.27 U42.27 U43.27 U44.27 U45.27 U46.27 U47.27
MEMORY.RA9: J7.10 J7.60 J7.110 J7.160 U1.M6 U40.26 U41.26 U42.26 U43.26 U44.26 U45.26 U46.26 U47.26
MEMORY.RA10: J7.11 J7.61 J7.111 J7.161 U1.T10 U40.23 U41.23 U42.23 U43.23 U44.23 U45.23 U46.23 U47.23
MEMORY.RA11: J7.12 J7.62 J7.112 J7.162 U1.P11 U40.25 U41.25 U42.25 U43.25 U44.25 U45.25 U46.25 U47.25
MEMORY.RA12: J7.13 J7.63 J7.113 J7.163 U1.T9 U40.4 U41.4 U42.4 U43.4 U44.4 U45.4 U46.4 U47.4
MEMORY.RA13: J7.14 J7.64 J7.114 J7.164 U1.T8 U40.28 U41.28 U42.28 U43.28 U44.28 U45.28 U46.28 U47.28
MEMORY.RA14: J7.15 J7.65 J7.115 J7.165 U1.T7 U40.3 U41.3 U42.3 U43.3 U44.3 U45.3 U46.3 U47.3
MEMORY.RA15: J7.16 J7.66 J7.116 J7.166 U1.T6 U40.31 U41.31 U42.31 U43.31 U44.31 U45.31 U46.31 U47.31
MEMORY.RA16: J7.17 J7.67 J7.117 J7.167 U40.2 U41.2 U42.2 U43.2 U44.2 U45.2 U46.2 U47.2
MEMORY.RD0: J7.18 J7.68 J7.118 J7.168 P2.6 U1.R15 U40.13 U41.13 U42.13 U43.13 U44.13 U45.13 U46.13 U47.13
MEMORY.RD1: J7.19 J7.69 J7.119 J7.169 P2.4 U1.R16 U40.14 U41.14 U42.14 U43.14 U44.14 U45.14 U46.14 U47.14
MEMORY.RD2: J7.20 J7.70 J7.120 J7.170 P2.2 U1.R14 U40.15 U41.15 U42.15 U43.15 U44.15 U45.15 U46.15 U47.15
MEMORY.RD3: J7.21 J7.71 J7.121 J7.171 P2.1 U1.T15 U40.17 U41.17 U42.17 U43.17 U44.17 U45.17 U46.17 U47.17
MEMORY.RD4: J7.22 J7.72 J7.122 J7.172 P2.3 U1.T14 U40.18 U41.18 U42.18 U43.18 U44.18 U45.18 U46.18 U47.18
MEMORY.RD5: J7.23 J7.73 J7.123 J7.173 P2.5 U1.T13 U40.19 U41.19 U42.19 U43.19 U44.19 U45.19 U46.19 U47.19
MEMORY.RD6: J7.24 J7.74 J7.124 J7.174 P2.7 U1.R12 U40.20 U41.20 U42.20 U43.20 U44.20 U45.20 U46.20 U47.20
MEMORY.RD7: J7.25 J7.75 J7.125 J7.175 P2.8(PIN8) U1.T12 U40.21 U41.21 U42.21 U43.21 U44.21 U45.21 U46.21 U47.21
MRD/: J6.E4 U7.8
MWR/: J6.E5 U7.9
N00036_USER_DESIGN_OUTPUTS0_D_1: L8.2 R53.1 R54.1 U32.5 U32.8 U33.5(VL)
N00036_USER_DESIGN_OUTPUTS0_DAA: L10.2 R55.1 R56.1 U35.5 U35.8 U36.5(VL)
N00038_USER_DESIGN_OUTPUTS0_D_1: C198.1 L7.2 U32.4
N00038_USER_DESIGN_OUTPUTS0_DAA: C201.1 L9.2 U35.4
N00044_USER_DESIGN_OUTPUTS0_D_1: U36.1 U37.2
N00044_USER_DESIGN_OUTPUTS0_DAA: U33.1 U34.2
N00046_USER_DESIGN_OUTPUTS0_D_1: R54.2 U33.8
N00046_USER_DESIGN_OUTPUTS0_DAA: R56.2 U36.8
N00048_USER_DESIGN_OUTPUTS0_D_1: R53.2 U33.2
N00048_USER_DESIGN_OUTPUTS0_DAA: R55.2 U36.2
N00060_USER_DESIGN_OUTPUTS0_D_1: U35.6 U37.3
N00060_USER_DESIGN_OUTPUTS0_DAA: U32.6 U34.3
PGOOD: R2012.2 U51.9
Q1E: Q9.2(E) R52.2
Q2E: C68.2 Q8.2 R45.1 R47.2
RDY/: J6.E6 U7.19
RESET: R2008.2 U1.M12 U2.T11 U49.2 U50.11
RESET/: J6.E1 U48.3
SEL: U7.11 U48.9
SHIELD1: J5.10
SHIELD2: J5.11
STDA_SSRX+: C2003.1 R2002.2 U2.A8
STDA_SSRX-: C2002.1 R2003.2 U2.B8
STDA_SSTX+: C2004.1 R2005.2 U2.E7
STDA_SSTX-: C2005.1 R2004.2 U2.E8
TCLK: P1.3 U1.C14 U2.C14
TDO: U1.E14 U2.C12
TMS: P1.11 U1.A15 U2.A15
V+12: C31.2 C32.2 C33.2 C39.2 C62.1 C64.1 C66.1 C199.1 C202.1 D5.1 J6.A1 J6.A2 J6.D1 J6.D2 R19.2 R45.2 U3.8 U5.1 U29.J1 U29.J2 U29.J3 U29.K1 U29.K2 U29.K3 U29.L1 U29.L2 U29.L3 U29.L5 U30.J1 U30.J2 U30.J3 U30.K1 U30.K2 U30.K3 U30.L1 U30.L2 U30.L3 U30.L5 U31.J1 U31.J2 U31.J3 U31.K1 U31.K2 U31.K3 U31.L1 U31.L2 U31.L3 U31.L5 U33.4 U34.7 U36.4 U37.7
VCLKC: R26.2 U39.11
VDX0: R8.2 RN2.5(2) U22.9 U38.9 U39.9 U48.11
VDX1: R6.2 RN2.6 U22.8 U38.8 U39.8 U48.12
VDX2: R4.2 RN2.7 U22.7 U38.7 U39.7 U48.13
VDX3: R2.2 RN2.8 U22.6 U38.6 U39.6 U48.14
VDX4: R7.2 RN3.5(2) U22.5 U38.5 U39.5 U48.15
VDX5: R5.2 RN3.6 U22.4 U38.4 U39.4 U48.16
VDX6: R3.2 RN3.7 U22.3 U38.3 U39.3 U48.17
VDX7: R1.2 RN3.8 U22.2 U38.2 U39.2 U48.18
VTTREF: C2016.1 U51.6
WAIT/: J6.E2 U48.2
N00286: C34.1 C35.1 C38.1 L5.2 L6.1
N00395: C35.2 C37.2 L6.2 R17.1
N00671: C3.1 R1.1
N00689: C5.1 R3.1
N00703: C7.1 R5.1
N00717: C9.1 R7.1
N00827: C4.1 R2.1
N00831: C6.1 R4.1
N00835: C8.1 R6.1
N00837: C10.1 R8.1
N04966: L7.1 L9.1
N15853: U2.T7 U12.K9
N15863: U2.R7 U13.K9
N15891: U2.M7 U12.B3
N15907: U2.P6 U12.F3
N15924: U2.N6 U13.F3
N15963: U2.L7 U13.B3
N16041: U2.T5 U12.J8 U13.J8
N16054: U2.R5 U12.K8 U13.K8
N16064: U2.T4 U12.K2 U13.K2
N16300: U2.P5 U12.L8
N16316: U2.N5 U13.L8
N16670: U2.P8 U12.K3 U13.K3
N16714: U2.P7 U12.K7 U13.K7
N16747: U2.T3 U12.L7 U13.L7
N17275: U2.R9 U12.B7
N17319: U2.T9 U12.A8
N17344: U2.N9 U13.A8
N17369: U2.P9 U13.B7
N17394: U2.M6 U12.F7
N17449: U2.T6 U13.F7
N44457: U1.K6 U10.8
N44464: U1.K3 U10.3 U10.13
N44478: U1.E2 U10.7
N44485: U1.L4 U10.10
N44490: U1.L5 U10.1
N45317: U2.M11 U11.1
N61996: C71.1 R50.2
N62056: Q8.1 R46.1 R51.1
N62230: C71.2 Q9.1 R48.1 R49.1
N62316: C72.2 Q8.3(E) R48.2
N62436: D5.3(C) R46.2
N62564: C69.1 C70.1 Q9.3 R47.1
N68133: C42.2 Q3.1 R21.1 R23.2
N70364: C43.2 Q3.2(E) R24.2
N80550: C40.2 R19.1
N81780: C69.2 R49.2
N84247: U6.22 U8.9 U8.12 U9.20
N103899: U6.19 U6.23 U8.8 U8.11 U9.19 U9.23
N108857: R12.2 U4.21
N108997: R14.2 U4.12
N111502: C11.1 C12.2 U3.1(OUT)
N111881: C11.2 C13.2 C14.2 R9.2 R10.2 R11.1
N113142: C15.2 L4.1 R9.1
N114006: C18.1 C20.1 Q1.1 R10.1 R13.2
N118214: C19.1 L3.3(OUT2) Q1.3
N118917: C16.2 L3.1 R11.2
N120412: C17.1 L3.2
N121910: C20.2 C21.2 Q1.2(E) R15.2
N123723: C17.2 Q2.3 R16.2
N124926: C19.2 C21.1 C22.2 Q2.1 R13.1 R15.1 R16.1 XTAL1.3
N129422: C22.1 L4.3(OUT2) Q2.2(S)
N221560: C18.2 XTAL1.4
N277989: Q3.3
N828385: R31.1 U22.19
N829333: R43.1 U31.G7
N829669: R44.1 U31.K7
N829685: U31.G5 U31.H5
N830942: D3.A R29.2
N831005: D3.C Q6.3
N831029: R39.1 U29.G7
N831181: R40.1 U29.K7
N831646: D2.A R28.2
N831650: D2.C Q5.3
N831853: R41.1 U30.G7
N831855: D1.A R27.2
N831859: D1.C Q4.3
N832005: R42.1 U30.K7
N832074: D4.A R30.2
N832078: D4.C Q7.3
N852308: R32.1 U22.17
N852494: R33.1 U22.15
N852683: R34.1 U22.13
N884986: C70.2 J3.1
N885188: C2.1 J2.1 L2.2
N885276: C1.1 J1.1 L1.2
N885442: L1.1 U34.6
N1358395: J5.6 R2003.1
N1358407: J5.8 R2004.1
N1358411: J5.9 R2005.1
N1358515: J5.2 R2000.1
N1358527: J5.3 R2001.1
N1358539: J5.5 R2002.1
N1406173: R2009.1 U50.9(XTAL2) Y1.3(OUTPUT)
N1406200: R2009.2 U50.8 Y1.1
N1406547: C2008.1 C2009.1 R2006.2 U50.4 U50.5
N1406997: R2007.1 U50.10 U50.19 U50.21
N1421557: L2.1 U37.6
N1432081: U2.M12 U11.8
N1432096: U2.R11 U11.3
N1432111: U2.P10 U11.7
N1432121: U2.T10 U11.10
N1438447: SW2.2 U49.3
N1472359: C2010.1 R2010.2 R2011.1 U51.1
N2993541: C43.1 R25.2

Pads without a net: D5 2; J6 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 E7 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22; J7 28 29 30 78 79 80 128 129 130 178 179 180; P1 10; SW2 3 4; U1 A2 A3 A4 A7 A8 A9 A10 A11 A12 A13 A14 B1 B2 B3 B8 B10 B12 B14 C1 C2 C4 C7 C8 C9 C10 C11 C13 D1 D3 D8 D9 D11 D12 E1 E3 E4 E6 E7 E8 E10 E11 F1 F3 F4 F5 F6 F7 F9 F10 G1 G5 G12 H1 H2 H5 H11 H13 H14 J3 J11 J12 J13 J14 K1 K2 K11 K12 K14 K15 K16 L1 L3 L7 L10 L11 L12 L13 L14 L16 M3 M4 M5 M7 M10 M13 M14 M15 M16 N4 N6 N9 N12 N14 N16 P4 P7 P9 P12 P13 P14 P15 P16 R3 R5 T2 T3 T4 T5; U2 A3 A4 A7 A9 A10 A12 B14 B15 B16 C4 C7 C8 C9 C13 C15 C16 D8 D9 D12 D14 D16 E6 E12 E13 E15 E16 F6 F7 F9 F12 F13 F14 F15 F16 G6 G11 G12 G14 G16 H11 H13 H14 H15 H16 J6 J13 J14 J16 K6 K11 K12 K14 K15 K16 L8 L10 L11 L12 L13 L14 L16 M3 M9 M10 M13 M14 M15 M16 N8 N12 N14 N16 P4 P12 P13 P14 P15 P16 R3 R12 R14 R15 R16 T2 T8 T12 T13 T14 T15; U3 4 5; U4 13 14 15 16 17; U6 20; U9 22; U10 2 4 5 6 9 12 14 15 16 17; U11 2 4 5 6 9 12 13 14 15 16 17; U12 A2 E2 E8 G3 R3 R7 R8; U13 A2 E2 E8 G3 R3 R7 R8; U22 12 14 16 18; U29 G5 H7 J7; U30 G5 H7 J7; U31 H7 J7; U34 1 5 8; U37 1 5 8; U40 1 30; U41 1 30; U42 1 30; U43 1 30; U44 1 30; U45 1 30; U46 1 30; U47 1 30; U48 1 19; U50 6 7 16 24 26; XTAL1 5; Y1 2 4

## Via types
v1: diameter 0.6, hole 0.3, TOP to BOTTOM, 715 vias
v2: diameter 0.5, hole 0.203, TOP to BOTTOM, 501 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V9: length 16
  TOP w0.102: U12.J2 v2(36.7,60.65) ; U13.J2 v2(37.5,46.84)
  TOP w0.2: U51.5 71.17,32.91 v1(71.15,32.89) ; U51.3 70.57,34.54 70.57,34.55 v1(69.7,34.55)
  POWER w0.5: P1.2 51.1,29.51 ; P1.2 49.5,29.51 ; P1.2 49.5,31.1 ; P1.2 51.1,31.1
  BOTTOM w0.5: C2011.1 C2012.1 C2013.1 70.75,30.64 v1(69.55,30.64)
1V2: length 31.2
  TOP w0.102: U2.H10 v2(61.25,48.9) ; U2.G7 v2(57.25,49.9) ; U1.H8 v2(47.9,77.94) ; U1.G7 v2(48.9,76.94) ; U1.J9 v2(45.9,79.94) ; U1.G9 v2(45.9,76.94) ; U1.H10 v2(44.9,77.94) ; U2.K10 v2(61.25,45.9) ; U2.G9 v2(60.25,49.9) ; U2.H8 v2(58.25,48.9) ; U2.J9 v2(60.25,46.9) ; U2.K8 v2(58.25,45.9) ; U1.J7 v2(48.9,79.94) ; U2.J7 v2(57.25,46.9) ; U1.K10 v2(44.9,80.94) ; U1.K8 v2(47.9,80.94)
  POWER w0.5: 46.96,29.51 P1.4 ; P1.4 46.96,31.1 ; P1.4 48.56,29.51 ; P1.4 48.56,31.1
  BOTTOM w0.5: C179.1 v2(49.15,41.55) ; C126.1 v2(49.15,53.74) ; C133.1 v1(70.39,52.55) ; C128.1 46,79.84 v2(45.9,79.94) ; C185.1 C178.1 60.34,37.9 59.94,37.49 v1(59.78,37.49) ; C127.1 v2(45.9,76.94) ; C129.1 C183.1 v1(55.79,77.06) ; C186.1 v1(70.39,51.55) ; C180.1 v2(49.15,40.45) ; C182.1 v1(70.2,59.95) ; C181.1 v1(70.2,58.84) ; C184.1 v1(38.6,69.85) ; C130.1 v1(55.6,68.65) ; C125.1 v2(49.15,54.74) ; C131.1 v1(54.6,68.65) ; C132.1 v1(37.6,69.85)
  vias: v1(87.25,68.33) v1(87.25,67.56) v1(87.25,66.8) v1(88.01,68.33) v1(88.01,67.56) v1(88.01,66.8) v1(88.77,68.33) v1(88.77,67.56) v1(88.77,66.8)
1V8: length 72.8
  TOP w0.102: U13.C3 v2(42.3,46.05) ; U12.C7 v2(42.3,55.84) ; U13.M9 v2(34.3,40.45) ; U13.E9 v2(40.7,40.45) ; U12.G9 v2(39.1,54.24) ; U13.C1 v2(42.3,47.65) ; U13.J1 v2(37.5,47.65) ; U13.A1 v2(43.9,47.65) ; U2.N2 v2(52.25,42.9) ; U2.R13 v2(64.25,40.9) ; U13.J9 v2(36.7,40.45) ; U12.G1 v2(39.1,61.45) ; U13.G1 v2(39.1,47.65) ; U2.N15 v2(66.25,42.9) ; U12.C3 v2(42.3,59.84) ; v2(35.2,53.15) 34.7,53.65 U12.M9 ; U2.D2 v2(52.25,52.9) ; U2.K4 v2(54.25,45.9) ; U12.J1 v2(36.7,61.45) ; U13.C9 v2(42.3,40.45) ; U12.A9 v2(43.9,54.24) ; U2.B4 v2(54.25,54.9) ; U13.E1 v2(40.7,47.65) ; U12.A1 v2(43.9,61.45) ; U13.G9 v2(39.1,40.45) ; U13.R1 v2(31.7,47.84) ; U12.R1 v2(31.9,61.45) ; U12.C9 v2(42.3,54.24) ; U12.C1 v2(42.3,61.45) ; U12.E1 v2(40.7,61.45) ; U2.B9 v2(60.25,54.9) ; U12.G7 v2(39.1,55.84) ; U2.G4 v2(54.25,49.9) ; U2.J2 v2(52.25,46.9) ; U12.J9 v2(36.7,54.24) ; U2.B13 v2(64.25,54.9) ; U2.N7 v2(57.25,42.9) ; U13.C7 v2(42.3,42.05) ; U12.E9 v2(40.7,54.24) ; U13.A9 v2(43.9,40.45) ; U13.G7 v2(39.1,42.05)
  TOP w0.2: U51.2 71.85,35.04 v1(72.35,34.55)
  TOP w0.5: C106.1 v1(74.03,44.95) ; C105.1 v1(72.3,41.12)
  INNER2 w0.5: P1.6 46.02,31.1 ; P1.6 46.02,29.51 ; P1.6 44.42,31.1 ; P1.6 44.42,29.51
  BOTTOM w0.5: C187.1 v2(36.4,38.95) ; C137.1 v2(49.15,44.59) ; C143.1 v2(49.15,48.34) ; C87.1 v1(51.7,60.95) ; C76.1 C191.1 v2(41.1,49.49) ; C135.1 v2(49.15,50.34) ; C136.1 v2(49.15,49.34) ; C78.1 v2(37.1,49.49) ; C88.1 v1(52.7,60.95) ; C141.1 v1(70.39,50.55) ; R2010.1 72.3,39.32 v1(72.3,41.12) 74.52,41.12 C2015.1 C2014.1 ; C140.1 v1(70.39,56.55) ; C196.1 v2(49.15,45.59) ; C86.1 v1(53.7,60.95) ; C75.1 v2(30.4,38.95) ; C192.1 v2(35.4,38.95) ; C79.1 v2(38.1,49.49) ; C138.1 v2(49.15,43.59) ; v2(49.2,47.45) 48.5,47.45 C85.1 ; C195.1 v1(50.7,60.95) ; C189.1 v2(34.4,38.95) ; C190.1 v2(33.4,38.95) ; C77.1 v2(36.1,49.49) ; C74.1 v2(31.4,38.95) ; C80.1 v2(39.1,49.49) ; C83.1 v1(39,63.24) ; C193.1 v1(36,63.24) ; C142.1 v2(49.15,51.34) ; C82.1 v1(38,63.24) ; C194.1 v1(37,63.24) ; C139.1 v1(41,63.24) ; C73.1 v2(32.4,38.95) ; C134.1 v2(49.15,42.59) ; C84.1 v1(40,63.24) ; C188.1 v2(40.1,49.49) ; C81.1 v1(42,63.24)
2V5: length 110.7
  TOP w0.1: U2.R8 58.75,41.45 58.3,41.9 v2(58.3,41.95)
  TOP w0.102: U2.F11 v2(62.25,50.9) ; U2.D10 v2(61.25,52.9) ; U1.L9 v2(45.9,81.94) ; U1.N7 v2(48.9,83.94) ; U1.J2 v2(52.9,79.94) ; U1.D2 53.85,74 v2(53.9,74) ; U2.D7 v2(57.25,52.9) ; U1.J10 v2(44.9,79.94) ; U2.D15 v2(66.25,52.9) ; U2.F8 v2(58.25,50.9) ; U1.G10 v2(44.9,76.94) ; U2.H6 v2(56.25,48.9) ; U2.G10 v2(61.25,49.9) ; U1.H6 v2(49.9,77.94) ; U1.F11 v2(43.9,75.94) ; U1.F8 v2(47.9,75.94) ; U2.J10 v2(61.25,46.9) ; U2.L9 v2(60.25,44.9) ; v2(60.25,43.95) 60.25,43.9 U2.N10 ; U1.R8 v2(47.9,85.94) ; U1.L6 v2(49.9,81.94) ; U2.E5 v2(55.25,51.9) ; U1.N2 v2(53.9,83.94) ; U1.R13 v2(41.9,85.94) ; U2.L6 v2(56.25,44.9) ; U1.R4 v2(51.9,85.94) ; U2.R4 v2(54.25,40.9) ; U1.E5 v2(50.9,74.94) ; U1.G4 v2(51.9,76.94) ; U1.N10 v2(44.9,83.94) ; U1.K4 v2(51.9,80.94)
  TOP w0.3: U10.20 67.7,72.65 67.45,72.4 67.45,72.02 v1(67.43,72) 68.69,72 ; U11.20 v1(73.55,48.77) 73.55,48.77 73.55,49.24 73.72,49.42 U11.19
  TOP w0.5: v1(61.65,81.49) 59.55,81.49 C176.1 ; C123.1 v1(31.1,82.34) ; C124.1 v1(62.15,65.34) ; C177.1 v1(75.15,70.84)
  BOTTOM w0.5: C155.1 C154.1 ; C155.1 69.35,46.15 69.3,46.2 ; C155.1 C157.1 ; C154.1 69.4,47.15 69.35,47.09 ; C154.1 C173.1 ; 36.75,78.04 C91.1 36.2,77.47 ; C104.1 C103.1 ; C104.1 C97.1 ; C104.1 46.6,68.65 ; C103.1 45.6,68.59 ; C103.1 C102.1 ; C153.1 52.18,67.9 ; C153.1 C119.1 ; C153.1 51.6,68.45 ; C157.1 69.3,45.15 ; C157.1 C145.1 ; 58.75,37.34 58.45,37.05 C174.1 ; C145.1 70.1,43.66 70.05,43.61 ; C145.1 69.3,44.15 69.25,44.09 ; 47.95,60.27 C156.1 ; C156.1 48.5,60.84 ; C156.1 C171.1 ; C98.1 48.6,68.69 ; C98.1 C116.1 ; C98.1 C97.1 ; C144.1 54,37.6 ; C144.1 53.42,37.05 ; C144.1 C99.1 ; C90.1 C89.1 ; C90.1 62.6,59.19 ; C90.1 63.18,59.74 ; C89.1 61.6,59.09 ; C89.1 C159.1 ; C174.1 58,37.7 ; C174.1 C175.1 ; 40.57,79.94 C96.1 ; C96.1 41.15,80.5 ; C96.1 C120.1 ; C171.1 C146.1 ; C171.1 48.7,61.84 ; C146.1 47.95,63.65 ; C146.1 48.65,62.84 ; C170.1 C175.1 ; C170.1 56,37.65 ; C170.1 C99.1 ; C175.1 57,37.7 ; 58.15,59.19 C158.1 ; C158.1 58.73,59.74 ; C158.1 C172.1 ; 36.2,80.62 C152.1 36.75,80.04 ; C116.1 49.6,68.69 ; C116.1 C119.1 ; 74.17,47.45 C150.1 ; C150.1 75.33,47.45 ; C150.1 74.75,48 ; 34.01,30.3 P1.14 ; P1.14 36.11,30.3 ; P1.14 35.06,29.25 ; P1.14 35.06,31.36 ; C99.1 55,37.7 ; C97.1 47.6,68.59 ; C120.1 C121.1 43.15,80.5 ; C120.1 42.15,80.4 42.2,80.44 ; C172.1 57.15,59.09 ; C172.1 56.4,59.74 ; 54.4,73.09 C93.1 53.85,73.67 ; C102.1 C101.1 ; C102.1 44.6,68.59 ; C101.1 43.6,68.59 ; C101.1 42.75,67.9 ; 68.22,72.65 C149.1 ; C149.1 68.8,73.2 ; C149.1 69.6,72.65 ; 43.95,74.47 C94.1 43.95,75.62 ; 89.92,73.04 C148.1 ; C148.1 C100.1 ; C148.1 90.5,73.6 ; 49.95,78.22 C151.1 50.5,78.79 ; C119.1 50.6,68.59 ; 55.7,80.7 C117.1 55.12,80.15 ; C122.1 50.33,75.94 ; 53.85,71.52 C92.1 54.4,72.09 ; 60.7,78.59 C169.1 ; C173.1 70.1,48.72 ; C173.1 69.55,48.15 ; C100.1 92.08,73.04 ; C100.1 91.5,73.6 ; C159.1 60.6,58.99 ; C159.1 59.8,59.74 ; C95.1 36.75,79.04 ; 48.17,75.94 C147.1 ; 44.15,80.5 C118.1 44.73,79.94
  vias: v1(97.41,68.07) v1(97.41,67.31) v1(97.41,66.55) v1(98.17,68.07) v1(98.17,67.31) v1(98.17,66.55)
3V3: length 46.6
  TOP w0.1: U2.J15 v2(66.25,46.9)
  TOP w0.102: U2.G13 v2(64.25,49.9) ; U1.D10 v2(44.9,73.94) ; U1.D7 v2(48.9,73.94) ; U1.J15 v2(39.9,79.94) ; U1.B9 v2(45.9,71.94) ; U1.K13 v2(41.9,80.94) ; U1.D15 v2(39.9,73.94) ; U1.G13 v2(41.9,76.94) ; U1.N15 v2(39.9,83.94) ; U1.B4 v2(51.9,71.94) ; U2.K13 v2(63.25,45.9) ; U1.B13 v2(41.9,71.94)
  TOP w0.2: v1(75.64,36.31) 75.63,36.3 74.5,36.3 74.12,35.91 U51.10 74.12,35.55 73.45,35.55 73.25,35.34 73.25,34.25 73.45,34.04 U51.7
  TOP w0.3: v1(76.1,50.09) 76.07,50.07 U11.18 ; U10.18 v1(69.94,71.35)
  TOP w0.5: U30.H5 v1(98.51,54.74) ; U29.H5 v1(89.21,54.74)
  INNER2 w0.5: P1.12 38.4,29.51 ; P1.12 36.8,31.1 ; P1.12 36.8,29.51 ; P1.12 38.4,31.1
  BOTTOM w0.2: 67.8,79.75 67.8,80 67.65,80.15 RN1.5 ; 67.8,79.75 RN1.6 ; 67.8,79.75 67.8,79.34 ; 67.8,78.94 68.45,78.94 v1(69.2,79.69) ; 67.8,78.94 67.8,79.34 ; 67.8,78.94 RN1.8 ; 67.8,79.34 RN1.7
  BOTTOM w0.5: C162.1 C109.1 ; C162.1 v1(58.7,78.29) ; C162.1 C110.1 C111.1 ; C114.1 v1(70.39,55.55) ; C115.1 v1(70.39,53.55) ; C164.1 C161.1 46.27,71.58 v2(45.9,71.94) 46.27,72.31 C107.1 C113.1 ; R2012.1 v1(75.64,36.31) ; C168.1 v1(70.39,54.55) ; v1(35.2,75.44) 35.3,75.54 C163.1 C160.1 C167.1 C112.1 ; C166.1 v1(57.5,71.19) ; C108.1 v1(71,70.79) ; C165.1 v1(57.5,72.19)
  vias: v1(106.3,65.69) v1(106.3,64.94) v1(106.35,69.5) v1(106.35,68.75) v1(106.35,68) v1(106.35,67.25) v1(106.35,66.5) v1(107.06,69.53) v1(107.06,68.76) v1(107.06,68) v1(107.1,67.25) v1(107.1,66.5) v1(107.1,65.69) v1(107.1,64.9)
5V: length 125
  TOP w0.2: U4.11 v1(75.1,60.35) ; U4.6 72.56,63.6 v1(72,63.05) ; U4.18 v1(82.3,60.35) ; U4.23 79.95,63.6 v1(79.5,63.15)
  TOP w0.5: XTAL1.2 XTAL1.1 v1(42.4,9.09) ; U5.3 31.23,15.97 v1(31.2,16) ; XTAL1.6 46.36,9.09 v1(46.35,9.1)
  INNER1 w0.5: v1(75.1,60.35) 75.1,60.22 75.25,60.07 75.25,37.22 73.7,35.67 73.7,32.3 69.15,27.75 69.15,22.45 55.79,9.09 46.36,9.09 v1(46.35,9.1) 46.34,9.09 v1(42.4,9.09) 39.4,12.09 39.4,14 37.4,16 v1(31.2,16) ; v1(75.1,60.35) 75.21,60.24 78.7,60.24 ; v1(75.1,60.35) 73.9,61.55 73.9,62.55 73.4,63.05 72.66,63.05 72.66,63.05 72.03,63.05 72.02,63.05 v1(72,63.05) ; 78.7,60.24 82.2,60.24 v1(82.3,60.35) ; 78.7,60.24 78.7,62.75 79.1,63.15 v1(79.5,63.15)
  BOTTOM w0.5: C26.1 C24.1 82.1,60.15 v1(82.3,60.35) ; v1(72,63.05) 72.02,63.05 72.03,63.05 72.91,63.05 C27.1 C30.1 ; C29.1 C28.1 80.1,63.15 v1(79.5,63.15) ; v1(75.1,60.35) 75.1,60.34 C25.1 C23.1
GND EARTH: length 78.9
  TOP w0.5: SW1.7 v1(78.84,83.69) ; SW1.8 v1(78.84,86.23) ; SW1.6 v1(78.84,81.15) ; SW1.5 v1(78.84,78.61)
  GND w0.5: J1.3 124.61,3.35 ; J1.3 122.53,3.35 ; J1.3 124.61,1.26 ; J1.3 122.53,1.26 ; 122.53,18.82 J2.3 ; J2.3 124.61,18.82 ; J2.3 122.53,16.74 ; J2.3 124.61,16.74 ; 117.45,23.9 J2.4 ; J2.4 119.53,21.82 ; J2.4 119.53,23.9 ; J2.4 117.45,21.82 ; 118.49,7.38 119.53,6.34 ; 118.49,7.38 117.45,6.34 ; 118.49,7.38 117.45,8.43 ; 118.49,7.38 119.53,8.43 ; J3.2 124.61,89.63 ; J3.2 124.61,91.72 ; J3.2 122.53,89.63 ; J3.2 122.53,91.72 ; J3.3 124.61,86.64 ; J3.3 122.53,86.64 ; J3.3 122.53,84.55 ; J3.3 124.61,84.55 ; J2.2 124.61,21.82 ; J2.2 124.61,23.9 ; J2.2 122.53,23.9 ; J2.2 122.53,21.82 ; J2.5 119.53,18.82 ; J2.5 117.45,16.74 ; J2.5 117.45,18.82 ; J2.5 119.53,16.74 ; 117.45,91.72 J3.4 ; J3.4 119.53,89.63 ; J3.4 119.53,91.72 ; J3.4 117.45,89.63 ; J3.5 119.53,84.55 ; J3.5 117.45,84.55 ; J3.5 117.45,86.64 ; J3.5 119.53,86.64 ; J1.5 119.53,1.26 ; J1.5 117.45,1.26 ; J1.5 117.45,3.35 ; J1.5 119.53,3.35 ; 123.57,7.38 124.61,8.43 ; 123.57,7.38 122.53,8.43 ; 123.57,7.38 124.61,6.34 ; 123.57,7.38 122.53,6.34
V12N: length 41.3
  TOP w0.5: U34.4 104.02,8.1 99.1,8.1 96.78,10.41 95.45,10.41 ; 95.45,25.89 96.75,25.89 99.5,23.14 103.6,23.14 U37.4
  POWER w0.5: J6.A4 13.23,35.43 ; J6.A4 12,34.19 ; J6.A4 12,35.43 ; J6.A4 13.23,34.19 ; J6.A3 13.23,33.4 ; J6.A3 12,33.4 ; J6.A3 12,32.16 ; J6.A3 13.23,32.16 ; J6.D3 7.23,32.16 ; J6.D3 6,33.4 ; J6.D3 6,32.16 ; J6.D3 7.23,33.4 ; 103.74,7.81 U34.4 ; U34.4 104.53,7.56 ; U34.4 105.31,9.39 ; 104.53,23.04 U37.4 ; U37.4 103.74,23.29 ; U37.4 103.49,24.08 ; 6,35.43 J6.D4 ; J6.D4 7.23,35.43 ; J6.D4 7.23,34.19 ; J6.D4 6,34.19
VCC: length 225.6
  TOP w0.2: v1(27.1,66.09) 26.86,66.34 U8.31 ; U8.7 16.81,71.84 v1(16.8,71.84)
  TOP w0.3: U50.32 v1(68.78,36.04) ; U9.31 v1(26.75,49.32) ; v1(27.45,72.29) 27.25,72.29 26.79,71.84 U8.42 ; v1(19.3,66.34) 19.29,66.34 U8.18 ; U6.7 16.69,88.6 v1(16.55,88.75) ; v1(16.75,83.54) 16.97,83.33 16.97,83.31 17.17,83.1 U6.18 ; U9.18 16.72,49.32 v1(16.55,49.15) ; U9.7 v1(16.69,54.82) ; U6.42 v1(26.87,88.6) ; U6.31 v1(26.87,83.1) ; U50.28 68.28,34.04 v1(68.78,33.54) U50.27 ; v1(26.9,55.24) 26.47,54.82 U9.42
  TOP w0.5: v1(88.7,10.2) 88.6,10.1 88.6,4.04 89.55,3.1 U32.2 94.03,3.1 L8.1 ; U48.20 v1(27.42,24.38) ; U35.2 v1(90.75,18.58) ; U39.20 v1(80.19,28.74) ; U42.32 v1(58.31,113.66) ; U41.32 v1(47.4,113.66) ; U38.20 v1(77.01,13.26) ; U40.32 v1(36.48,113.66) ; U47.32 v1(112.88,113.66) ; U7.20 v1(27.42,39.62) ; U46.32 v1(101.97,113.66) ; U32.9 v1(90.75,11.99) ; U43.32 v1(69.22,113.66) ; L10.1 v1(94.39,16.45) ; 109.65,45.56 v1(108.22,45.56) ; U44.32 v1(80.14,113.66) ; U45.32 v1(91.05,113.66) ; U35.9 v1(90.75,27.46) ; v1(66.46,29.34) 65.94,29.86 U49.4
  TOP w0.8: R27.1 v1(117.76,49.86) ; R28.1 v1(117.76,43.73) ; R30.1 v1(117.76,31.47) ; R29.1 v1(117.76,37.6)
  POWER w0.5: J6.D24 7.23,86.23 ; J6.D24 6,86.23 ; J6.D24 7.23,84.99 ; J6.D24 6,84.99 ; 12,84.99 J6.A24 ; J6.A24 12,86.23 ; J6.A24 13.23,86.23 ; J6.A24 13.23,84.99 ; J6.D23 7.23,82.96 ; J6.D23 6,82.96 ; J6.D23 6,84.2 ; J6.D23 7.23,84.2 ; 12,82.96 J6.A23 ; J6.A23 12,84.2 ; J6.A23 13.23,82.96 ; J6.A23 13.23,84.2 ; 120.33,62.36 J5.1 ; J5.1 121.57,62.36 ; J5.1 121.57,61.13
  BOTTOM w0.3: 44.65,95.65 44.7,95.59 45.1,95.59 45.25,95.75 J7.34 ; 44.65,95.65 44.65,94.34 44.95,94.04 v1(45.85,94.04) ; 44.65,95.65 J7.32 ; C2007.2 68.73,33.49 v1(68.78,33.54) ; 78.94,107.65 v1(78.94,108.65) ; 78.94,107.65 78.85,107.65 78.55,107.34 J7.133 ; 78.94,107.65 79.15,107.43 J7.135 ; v1(78.94,108.65) 78.89,108.59 78.3,108.59 77.95,108.25 J7.131 ; v1(78.94,108.65) 79,108.65 79.75,107.9 J7.137 ; J7.38 46.45,94.65 v1(45.85,94.04) ; 78.85,93.79 79.4,93.79 ; 78.85,93.79 J7.134 ; 78.85,93.79 v1(78.25,93.79) J7.132 ; 79.4,93.79 79.7,93.79 80.05,94.15 J7.138 ; 79.4,93.79 79.45,93.84 J7.136 ; J7.82 63.25,93.79 ; 63.25,93.79 63.25,93.79 63.85,93.79 ; 63.25,93.79 v1(62.3,93.79) ; 93.85,95.34 94.45,95.34 ; 93.85,95.34 93.25,95.34 ; 93.85,95.34 J7.184 ; 94.45,95.34 94.8,95.34 95.05,95.59 J7.188 ; 94.45,95.34 J7.186 ; J7.31 44.35,107.84 ; 44.35,107.84 v1(44.35,109.09) 44.4,109.04 45.5,109.04 46.15,108.4 46.15,107.84 ; 44.35,107.84 44.65,107.84 44.95,107.54 J7.33 ; v1(45.85,94.04) J7.36 ; J7.181 92.95,103.79 93.25,103.5 93.55,103.5 ; J7.86 64.45,93.79 ; 64.45,93.79 63.85,93.79 ; 64.45,93.79 64.75,93.79 65.05,94.09 J7.88 ; 93.25,95.34 v1(93.25,93.69) ; 93.25,95.34 J7.182 ; J7.185 94.15,103.5 ; 94.15,103.5 v1(94.55,103.5) 94.75,103.69 J7.187 ; 94.15,103.5 93.55,103.5 ; J7.84 63.85,93.79 ; 62.95,104.04 63.55,104.04 ; 62.95,104.04 J7.81 ; 62.95,104.04 62.4,104.04 v1(61.9,103.54) ; 63.55,104.04 64.15,104.04 ; 63.55,104.04 J7.83 ; J7.35 45.55,107.54 45.85,107.84 46.15,107.84 ; 46.15,107.84 J7.37 ; J7.87 64.75,104.25 64.55,104.04 64.15,104.04 ; R2007.2 v1(67.6,30.69) ; 64.15,104.04 J7.85 ; 93.55,103.5 J7.183
  BOTTOM w0.5: C2007.2 66.04,33.49 R2006.1 ; 25.53,48.65 26.08,48.65 v1(26.75,49.32) ; C55.1 114.73,113.66 v1(112.88,113.66) ; C53.1 38.1,113.66 v1(36.48,113.66) ; v1(58.31,113.66) 60.82,113.66 60.83,113.68 C51.1 ; C52.1 81.86,113.66 v1(80.14,113.66) ; C50.1 103.69,113.66 v1(101.97,113.66) ; 25.7,82.97 26.75,82.97 v1(26.87,83.1) ; C46.1 26.01,72.29 v1(27.45,72.29) ; v1(27.42,24.38) 27.4,24.39 C2006.1 ; C200.1 91,27.22 v1(90.75,27.46) ; R2008.1 v1(66.46,29.34) ; C54.1 70.95,113.66 v1(69.22,113.66) ; v1(91.05,113.66) 92.27,113.66 C48.1 ; v1(90.75,11.99) 91,11.74 C197.1 ; v1(27.42,39.62) 27.4,39.63 C45.1 ; C49.1 49.02,113.66 v1(47.4,113.66)
0: length 660.3
  TOP w0.102: U2.L2 v2(52.25,44.9) ; U12.N1 v2(33.5,61.45) ; U2.H9 v2(60.25,48.9) ; U1.L15 v2(39.9,81.94) ; U2.H7 v2(57.25,48.9) ; U1.N13 v2(41.9,83.94) ; U12.J7 v2(36.7,55.84) ; U1.G8 v2(47.9,76.94) ; U1.G2 v2(53.9,76.94) ; U13.H2 v2(38.3,46.84) ; U1.M8 v2(47.9,82.94) ; U2.L15 v2(66.25,44.9) ; U1.A1 v2(54.9,70.94) ; U12.P9 v2(32.7,54.24) ; U1.G15 v2(39.9,76.94) ; U2.R10 v2(61.25,40.9) ; U1.D13 v2(41.9,73.94) ; U2.G8 v2(58.25,49.9) ; v2(52.4,49.9) 52.4,49.74 U2.G2 ; U1.H9 v2(45.9,77.94) ; U2.D4 v2(54.25,52.9) ; U1.T16 v2(38.9,86.94) ; U12.A3 v2(43.9,59.84) ; U2.A1 v2(51.25,55.9) ; U1.J5 v2(50.9,79.94) ; U1.K7 v2(48.9,80.94) ; U13.E3 v2(40.7,46.05) ; U2.P3 v2(53.25,41.9) ; U2.H12 v2(63.25,48.9) ; U12.B2 v2(43.1,60.65) ; U13.E7 v2(40.7,42.05) ; U13.D2 v2(41.5,46.84) ; U13.N1 v2(33.5,47.65) ; U2.B11 v2(62.25,54.9) ; U1.B7 v2(47.9,71.94) ; U13.J7 v2(36.7,42.05) ; U1.T1 v2(54.9,86.94) ; U2.A16 v2(67.25,55.9) ; U1.B11 v2(43.9,71.94) ; U2.E9 v2(60.25,51.9) ; U2.K9 v2(60.25,45.9) ; U12.H2 v2(38.3,60.65) ; U12.J3 v2(36.7,59.84) ; U2.M8 v2(58.25,43.9) ; U1.E9 v2(46.88,74.97) ; U2.J5 v2(55.25,46.9) ; U13.F2 v2(39.9,46.84) ; U12.E7 v2(40.7,55.84) ; U1.H7 v2(48.9,77.94) ; U2.B7 v2(57.25,54.9) ; U12.F2 v2(39.9,60.65) ; U13.H8 v2(38.3,41.24) ; U13.B2 v2(43.1,46.84) ; U1.L2 v2(53.9,81.94) ; U2.D13 v2(64.25,52.9) ; U2.T16 v2(67.25,39.9) ; U12.A7 v2(43.9,55.84) ; U13.F8 v2(39.9,41.24) ; U12.D8 v2(41.5,55.05) ; U12.D2 v2(41.5,60.65) ; U13.J3 v2(36.7,46.05) ; U1.J8 v2(47.9,79.94) ; U1.H12 v2(42.9,77.94) ; U1.R6 v2(49.9,85.94) ; U13.A7 v2(43.9,42.05) ; U1.R10 v2(44.9,85.94) ; U1.D4 v2(51.9,73.94) ; U1.A16 v2(38.9,70.94) ; U12.H8 v2(38.3,55.05) ; U12.E3 v2(40.7,59.84) ; U2.N13 v2(64.25,42.9) ; U2.R6 v2(56.25,40.9) ; U13.P9 v2(32.7,40.45) ; U2.K7 v2(57.25,45.9) ; U13.B8 v2(43.1,41.24) ; U13.D8 v2(41.5,41.24) ; U12.F8 v2(39.9,55.05) ; U12.B8 v2(43.1,55.05) ; U2.T1 v2(51.25,39.9) ; U1.P3 v2(52.9,84.94) ; U2.J8 v2(58.25,46.9) ; U2.G15 v2(66.25,49.9) ; U13.A3 v2(43.9,46.05) ; U1.K9 v2(45.9,80.94)
  TOP w0.2: v1(24.17,74.81) 24.19,74.84 U8.48 ; U4.10 v1(72.34,61) ; U4.24 v1(82.3,64.25) ; U51.4 70.6,34.04 70.3,33.75 v1(70.3,32.89) ; U50.17 63.66,31.34 63.8,31.19 64,31.19 64.16,31.35 U50.18 ; U4.5 v1(75.1,64.25) ; U51.8 77.29,34.54 v1(77.68,34.94) ; U4.19 v1(79.54,61)
  TOP w0.25: v1(115.05,51.71) Q4.2 ; v1(115.05,33.32) Q7.2 ; v1(115.05,45.58) Q5.2 ; v1(115.05,39.45) Q6.2
  TOP w0.3: U50.33 65.16,34.54 U50.12 62.52,34.54 v1(62.02,34.04) U50.13 ; U50.33 65.66,34.54 ; U50.33 65.16,34.04 U50.20 ; U9.21 v1(16.69,47.82) ; U9.28 v1(26.75,47.82) ; U6.21 16.94,81.6 v1(16.75,81.79) ; U50.1 67.16,37.15 v1(67.65,37.65) ; U6.10 19.01,87.1 v1(19.6,87.69) ; U50.14 62.52,33.54 v1(62.02,33.04) U50.15 ; U8.1 v1(16.81,74.84) ; 65.66,34.54 66.16,35.04 U50.3 66.16,37.17 v1(66.66,37.67) U50.2 ; 65.66,34.54 U50.29 v1(68.78,34.54) ; v1(15.9,51.34) 16.42,50.82 U9.15 ; 68.69,66.8 v1(69.94,66.8) ; v1(27.1,85.09) 26.61,84.6 U6.34 ; U6.28 v1(26.87,81.6) ; U50.25 v1(68.78,32.54) ; U50.23 66.66,30.7 v1(66.65,30.7) 66.16,31.19 U50.22 ; U6.24 17.28,80.1 16.85,79.67 v1(16.85,79.25) ; v1(24.17,74.81) 24.17,73.94 24.77,73.34 U8.45 ; U9.34 v1(26.75,50.82) ; v1(62.85,31.84) 62.88,31.82 U50.17 ; U9.45 v1(26.75,56.32) ; U8.34 v1(26.87,67.84) ; U11.11 v1(76.06,54.62) ; U6.25 v1(24.41,80.1) ; U8.39 26.89,70.34 v1(26.9,70.34) ; U6.4 19.21,90.1 v1(19.45,90.34) ; v1(19.4,64.44) 19.01,64.84 U8.21 ; U6.39 26.53,87.1 26.54,87.11 v1(26.96,87.11) ; v1(16.55,84.79) 16.74,84.6 17.17,84.6 17.17,84.6 U6.15 ; U9.4 v1(16.69,56.32) ; v1(16.65,53.15) 16.82,53.32 U9.10 ; U8.10 v1(16.81,70.34) ; U9.39 v1(26.75,53.32) ; v1(27.05,65.19) 26.9,65.05 26.88,65.05 26.67,64.84 U8.28 ; U9.25 v1(26.75,46.32) ; U8.15 v1(16.81,67.84) ; U9.24 v1(16.69,46.32) ; U8.4 v1(16.81,73.34) ; U6.45 v1(26.87,90.1)
  TOP w0.5: U35.1 v1(90.75,17.3) ; C38.2 v1(110.63,79.46) ; C123.2 v1(31.1,84.79) ; U38.1 v1(67.66,13.26) ; U7.10 v1(15.26,28.19) ; U43.24 72.36,103.5 v1(72.6,103.75) ; C12.1 36.38,22.23 U3.2 33.56,22.23 v1(33.5,22.3) ; U32.7 v1(90.75,9.45) ; v1(84.35,93.79) 84.35,94.11 84.85,94.62 U45.16 ; C39.1 v1(86.36,87.75) ; U47.16 v1(109.24,94.62) ; v1(98.35,94.62) U46.16 ; C16.1 v1(42.8,19.14) ; U48.10 v1(15.26,12.95) ; C176.2 60.4,76.15 v1(60.4,77) ; v1(75.45,93.09) 75.45,94.05 74.88,94.62 U44.16 ; U47.24 v1(112.88,103.5) ; C15.1 v1(43.18,23.08) ; U32.10 v1(90.75,13.26) ; C68.1 v1(94.96,87.78) ; C106.2 v1(76.87,44.95) ; U40.24 v1(36.48,103.5) ; C37.1 96.3,76.11 96.3,76.65 v1(96.34,76.65) ; C72.1 v1(96.83,83.05) ; 82.73,17.3 v1(81.35,17.3) ; U35.3 v1(90.75,19.84) ; U43.16 v1(66,94.62) ; C36.1 v1(110.63,74.46) ; v1(30.95,22.34) 30.84,22.23 U3.7 ; U38.10 v1(70.53,1.83) ; U41.24 50.69,103.5 v1(50.7,103.5) ; R23.1 v1(90.69,79.05) ; C14.1 v1(42.14,22.95) ; v1(89.8,76.5) 90.14,76.5 R18.1 ; v1(41.65,18.35) 41.65,18.39 41.65,18.4 C13.1 ; R52.1 v1(112.78,76.47) ; U32.3 91.43,4.37 91.13,4.07 90.83,4.37 v1(90.75,4.37) ; U36.3 v1(98.73,27.16) ; 82.73,1.83 v1(84.11,1.83) ; U32.1 v1(90.75,1.83) ; U39.10 70.71,17.31 v1(70.85,17.45) ; v1(97.35,86.15) 97.35,86.66 R51.2 ; U40.16 v1(32.84,94.62) ; U46.24 v1(105.35,103.5) ; v1(69.95,61.95) C124.2 ; C40.1 v1(86.07,86.86) ; R24.1 v1(88.65,79.55) ; C105.2 v1(80.18,39.4) ; U22.10 v1(101.58,34.13) ; R25.1 v1(86.36,79.55) ; U41.16 v1(43.76,94.62) ; C177.2 v1(81.35,70.79) ; U39.1 v1(67.66,28.74) ; U3.3 v1(33.62,23.5) ; 100.15,45.56 v1(101.58,45.56) ; U45.24 v1(91.05,103.5) ; U42.16 v1(54.67,94.62) ; U49.1 v1(62.43,29.86) ; U33.3 v1(98.73,11.68) ; SW2.1 v1(59.25,27.8) ; U3.6 v1(30.78,23.5) ; U42.24 v1(58.35,103.5) ; U44.24 v1(80.14,103.5) ; U35.10 v1(90.75,28.73) ; U35.7 v1(90.75,24.93)
  GND w0.5: 2.5,30.86 J6.F1 ; J6.F1 2.5,29.62 ; J6.F1 3.73,30.86 ; J6.F1 3.73,29.62 ; 118.83,65.86 J5.7 ; J5.7 119.45,64.44 ; J5.7 118.83,64.63 ; 8.5,87.53 J6.C24 ; J6.C24 8.5,88.77 ; J6.C24 9.73,88.77 ; J6.C24 9.73,87.53 ; J6.C2 9.73,31.65 ; J6.C2 8.5,32.89 ; J6.C2 9.73,32.89 ; J6.C2 8.5,31.65 ; J6.F23 3.73,86.74 ; J6.F23 3.73,85.5 ; J6.F23 2.5,86.74 ; J6.F23 2.5,85.5 ; 2.5,31.65 J6.F2 ; J6.F2 2.5,32.89 ; J6.F2 3.73,31.65 ; J6.F2 3.73,32.89 ; P1.9 40.94,33.64 ; P1.9 40.94,32.05 ; P1.9 39.34,32.05 ; P1.9 39.34,33.64 ; 8.5,30.86 J6.C1 ; J6.C1 8.5,29.62 ; J6.C1 9.73,29.62 ; J6.C1 9.73,30.86 ; 120.33,68.13 J5.4 ; J5.4 120.95,69.55 ; J5.4 120.95,67.94 ; 49.5,33.64 P1.1 ; P1.1 49.5,32.05 ; P1.1 51.1,32.05 ; P1.1 51.1,33.64 ; P1.13 35.86,33.64 ; P1.13 34.26,33.64 ; P1.13 35.86,32.05 ; P1.13 34.26,32.05 ; 8.5,86.74 J6.C23 ; J6.C23 8.5,85.5 ; J6.C23 9.73,86.74 ; J6.C23 9.73,85.5 ; 44.42,32.05 P1.5 ; P1.5 44.42,33.64 ; P1.5 46.02,33.64 ; P1.5 46.02,32.05 ; J6.F24 3.73,88.77 ; J6.F24 2.5,88.77 ; J6.F24 3.73,87.53 ; J6.F24 2.5,87.53
  BOTTOM w0.3: 96.55,104.15 95.95,104.15 ; 96.55,104.15 J7.193 ; 96.55,104.15 97.15,104.15 ; 95.95,104.15 J7.191 ; 95.95,104.15 95.75,104.15 95.35,104.54 J7.189 ; J7.40 47.05,96.65 48.65,95.04 51.2,95.04 51.25,95.09 ; 68,99.84 68.05,99.79 J7.98 ; 68,99.84 67.45,99.84 ; 68,99.84 68.2,99.84 68.65,99.4 J7.100 ; J7.95 67.15,104.04 ; 67.15,104.04 66.55,104.04 ; 67.15,104.04 67.45,104.04 67.75,104.34 ; 96.25,99.65 95.95,99.65 95.65,99.34 J7.190 ; 96.25,99.65 J7.192 ; 96.25,99.65 96.85,99.65 ; 97.75,104.15 v1(98.35,104.15) J7.199 ; 97.75,104.15 97.15,104.15 ; 97.75,104.15 J7.197 ; J7.50 53.65,96.04 53.3,95.69 53.05,95.69 ; 51.85,95.69 52.45,95.69 ; 51.85,95.69 J7.44 ; 51.85,95.69 51.25,95.69 ; 52.45,95.69 53.05,95.69 ; 52.45,95.69 J7.46 ; J7.142 81.25,93.79 ; 81.25,93.79 v1(80.65,93.79) J7.140 ; 81.25,93.79 81.85,93.79 ; J7.195 97.15,104.15 ; 50.95,104.5 50.75,104.29 50.75,103.54 v1(50.7,103.5) 49.85,103.5 49.3,104.04 49.3,105.59 48.8,106.09 J7.39 ; 50.95,104.5 J7.41 ; 50.95,104.5 51.55,104.5 ; J7.49 53.35,104.9 52.95,104.5 52.75,104.5 ; 67.45,99.84 66.85,99.84 ; 67.45,99.84 J7.96 ; C2007.1 68.5,34.54 v1(68.78,34.54) ; v1(67.65,37.65) 67.65,36.88 67.47,36.7 ; 52.75,104.5 52.15,104.5 ; 52.75,104.5 J7.47 ; 52.15,104.5 J7.45 ; 52.15,104.5 51.55,104.5 ; v1(50.3,92.75) 51.25,93.69 51.25,95.09 ; 67.75,104.34 68.35,104.94 J7.99 ; 67.75,104.34 J7.97 ; 83.05,93.79 J7.148 ; 83.05,93.79 83.1,93.79 83.3,94 83.3,94.23 83.65,94.58 J7.150 ; 83.05,93.79 82.45,93.79 ; 66.55,104.04 J7.93 ; 66.55,104.04 66.05,104.04 v1(65.95,104.15) ; J7.194 96.85,99.65 ; 96.85,99.65 97.45,99.65 ; J7.146 82.45,93.79 ; 82.45,93.79 81.85,93.79 ; J7.89 65.35,104.29 65.55,104.09 65.9,104.09 v1(65.95,104.15) ; 82.75,107.59 83.05,107.59 83.35,107.29 J7.149 ; 82.75,107.59 J7.147 ; 82.75,107.59 82.15,107.59 ; 53.05,95.69 J7.48 ; v1(65.95,104.15) J7.91 ; J7.144 81.85,93.79 ; J7.200 v1(98.65,99.65) 98.05,99.65 ; 51.55,104.5 J7.43 ; 66.85,99.84 J7.94 ; 66.85,99.84 v1(66.2,99.84) ; 51.25,95.69 J7.42 ; 51.25,95.69 51.25,95.09 ; v1(79.9,108.69) 80.35,108.25 80.35,107.59 ; v1(66.2,99.84) 66.25,99.79 J7.92 ; v1(66.2,99.84) 65.65,99.29 J7.90 ; J7.196 97.45,99.65 ; 97.45,99.65 98.05,99.65 ; 80.35,107.59 80.95,107.59 ; 80.35,107.59 J7.139 ; J7.143 81.55,107.59 ; 81.55,107.59 80.95,107.59 ; 81.55,107.59 82.15,107.59 ; J7.198 98.05,99.65 ; 80.95,107.59 J7.141 ; J7.145 82.15,107.59
  BOTTOM w0.5: C3.2 C5.2 ; C5.2 C7.2 ; C5.2 v1(89.4,44.34) ; C192.2 v1(35.4,36.34) ; R12.1 76.6,63.55 75.89,64.25 v1(75.1,64.25) 75.01,64.34 C30.2 C27.2 ; C98.2 C97.2 v1(47.6,65.69) ; C126.2 v2(46.65,53.74) ; C47.2 26.13,81.6 v1(26.87,81.6) ; C129.2 C183.2 v1(58.46,77.06) ; C2006.2 27.15,22.59 v1(27.65,23.09) ; C2003.2 C2002.2 C2000.2 C2001.2 C2005.2 C2004.2 v1(112.48,59.81) ; v1(82.3,64.25) 82.11,64.44 C29.2 C28.2 ; C99.2 v1(55,35.24) ; v1(90.75,4.37) 90.98,4.14 C198.2 ; v2(46.88,74.97) 46.9,74.99 C127.2 ; v2(46.88,74.97) 47.95,74.97 47.97,74.94 C147.2 C122.2 ; v2(46.88,74.97) 45.78,74.97 45.7,75.04 C94.2 ; v1(26.75,46.32) 26.21,46.85 C44.2 ; C85.2 47.3,47.45 v2(46.65,47.45) ; C179.2 v2(46.65,41.55) ; v1(79.25,111.16) 79.25,111.19 79.93,111.88 C52.2 ; C136.2 v2(46.65,49.34) ; C131.2 v1(54.6,65.64) ; C81.2 v1(42,65.85) ; C133.2 v1(73,52.55) ; C187.2 v1(36.4,36.34) ; C170.2 C175.2 C174.2 58.45,36.05 v1(58.95,36.55) 60.25,36.55 C178.2 C185.2 ; C45.2 v1(27.39,37.84) ; C77.2 v2(36.1,51.99) ; v2(41.1,51.99) C191.2 C76.2 ; v1(98.73,27.16) 98.87,27.02 C202.2 ; C156.2 v1(46.14,60.84) ; C100.2 C148.2 v1(90.5,71.19) ; v1(71.91,47.15) C154.2 C155.2 C157.2 C145.2 ; C75.2 v1(30.4,36.34) ; v1(36.1,111.16) 36.1,111.19 36.65,111.75 C53.2 ; C171.2 v1(46.14,61.84) ; v1(72.34,61) 72.69,61.34 C23.2 C25.2 ; C194.2 v1(37,65.85) ; C2011.2 C2012.2 C2013.2 67.82,28.89 v1(67.66,28.74) ; R41.2 v1(102.75,54.45) ; v2(42.9,77.94) 43.15,78.19 C121.2 ; C200.2 91.04,29.02 v1(90.75,28.73) ; C181.2 v1(67.59,58.84) ; C193.2 v1(36,65.85) ; C117.2 v1(55.7,78.34) ; C103.2 v1(45.6,65.69) ; R44.2 v1(108.05,52.15) ; v1(112.65,111.79) 114.66,111.79 C55.2 ; C87.2 v1(51.7,58.34) ; C80.2 v2(39.1,51.99) ; v1(90.4,113.09) 90.4,112.79 90.9,112.29 C48.2 ; C195.2 v1(50.7,58.34) ; C130.2 v1(55.6,65.64) ; v1(46.8,111.16) 46.8,111.19 47.35,111.75 C49.2 ; C125.2 v2(46.65,54.74) ; C159.2 v1(60.6,61.55) ; C73.2 v1(32.4,36.34) ; v2(51.9,73.94) 52.75,73.09 C93.2 C92.2 ; v1(70.3,32.89) 70.3,34.05 70.8,34.55 C2010.2 71.19,34.55 72.2,33.54 R2011.2 ; C83.2 v1(39,65.85) ; C102.2 v1(44.6,65.69) ; C54.2 69.62,111.88 v1(68.5,113) ; C2015.2 C2014.2 79.38,38.59 v1(80.18,39.4) ; C121.2 C118.2 ; C121.2 C120.2 C96.2 ; v1(98.73,11.68) 98.87,11.54 C199.2 ; C138.2 v2(46.65,43.59) ; C180.2 v2(46.65,40.45) ; C51.2 58.53,111.88 v1(57.8,111.15) ; C33.1 29.79,22.34 v1(30.95,22.34) 31.08,22.48 C32.1 ; v1(37.9,72.5) 37.15,72.5 C112.2 C167.2 C160.2 C163.2 ; v1(68.5,37.65) 68.5,38.3 C2008.2 ; v1(89.4,35.95) C6.2 C4.2 C9.2 ; C90.2 v1(62.6,61.55) ; v1(67.35,71.19) 67.35,71.19 68.35,71.19 C149.2 ; C186.2 v1(73,51.55) ; C2016.2 v1(77.68,34.94) ; R39.2 v1(93.3,54.24) ; C173.2 v1(71.91,48.15) ; v1(90.75,30) 90.8,30.05 C10.2 C8.2 ; v1(49.6,65.69) C116.2 C119.2 C153.2 ; C31.1 34.55,22.3 v1(33.5,22.3) ; C139.2 v1(41,65.85) ; C91.2 C95.2 C152.2 v1(34.39,80.04) ; C190.2 v1(33.4,36.34) ; C182.2 v1(67.59,59.95) ; C134.2 v2(46.65,42.59) ; R43.2 v1(112.4,53.99) ; C196.2 v2(46.65,45.59) ; C151.2 48.9,78.75 v2(48.9,77.94) ; C142.2 v2(46.65,51.34) ; C115.2 v1(73,53.55) ; C86.2 v1(53.7,58.34) ; R42.2 v1(98.5,52.15) ; C50.2 101.63,111.88 v1(100.9,111.15) ; C79.2 v2(38.1,51.99) ; C114.2 v1(73,55.55) ; C164.2 C161.2 47.27,71.31 v2(47.9,71.94) 47.27,72.58 C107.2 C113.2 ; C141.2 v1(73,50.55) ; C137.2 v2(46.65,44.59) ; C82.2 v1(38,65.85) ; C104.2 v1(46.6,65.69) ; C78.2 v2(37.1,51.99) ; C74.2 v1(31.4,36.34) ; C88.2 v1(52.7,58.34) ; C172.2 v1(57.15,61.55) ; C101.2 v1(43.6,65.69) ; C84.2 v1(40,65.85) ; C135.2 v2(46.65,50.34) ; C111.2 C110.2 C162.2 C109.2 C169.2 62.6,80.15 v1(63.2,79.54) ; C132.2 v1(37.6,67.24) ; C166.2 v1(60.1,71.19) ; R14.1 79.1,59.74 79.45,60.09 79.45,60.91 v1(79.54,61) 79.69,61.15 C26.2 C24.2 ; v1(90.75,19.84) 90.98,19.62 92.13,19.62 ; C144.2 v1(54,35.24) ; C168.2 v1(73,54.55) ; C143.2 v2(46.65,48.34) ; C46.2 24.48,74.51 v1(24.17,74.81) ; C128.2 46,77.94 v2(45.9,77.94) ; C165.2 v1(60.1,72.19) ; C108.2 v1(71,73.4) ; C146.2 v1(46.14,62.84) ; R40.2 v1(89.1,52.24) ; C197.2 91.04,13.54 v1(90.75,13.26) ; C189.2 v1(34.4,36.34) ; C140.2 v1(73,56.55) ; C150.2 v1(76.1,46.45) ; C89.2 v1(61.6,61.55) ; C188.2 v2(40.1,51.99) ; C184.2 v1(38.6,67.24) ; C158.2 v1(58.15,61.55)
  vias: v1(31.95,13.25) v1(31.95,11.98) v1(31.95,10.71) v1(33.22,13.25) v1(33.22,11.98) v1(33.22,10.71) v1(34.49,13.25) v1(34.49,11.98) v1(34.49,10.71) v1(35.76,13.25) v1(35.76,11.98) v1(35.76,10.71) v1(37.03,13.25) v1(37.03,11.98) v1(37.03,10.71) v1(38.3,13.25) v1(38.3,11.98) v1(38.3,10.71) v1(90.2,65.94) v1(90.2,65.15) v1(91,65.94) v1(91,65.15) v1(91.8,65.94) v1(91.8,65.15) v1(92.6,65.94) v1(92.6,65.15) v1(99.2,65.94) v1(99.2,65.15) v1(100,65.94) v1(100,65.15) v1(100.8,65.94) v1(100.8,65.15) v1(109,65.94) v1(109,65.15) v1(109.8,65.94) v1(109.8,65.15) v1(110.6,65.94) v1(110.6,65.15) v1(111.4,65.94) v1(111.4,65.15)
A0: length 19.7
  TOP w0.2: U9.36 23.73,51.82 23.7,51.79 21.16,51.79 19.8,50.44 19.8,48.59 19.65,48.44 19.65,46.65 18.7,45.7 16.2,45.7 15.35,46.55 10.92,46.55 J6.B8
A1: length 20.9
  TOP w0.2: U9.35 21.27,51.32 20.3,50.34 20.3,48.45 20.05,48.2 20.05,46.48 18.87,45.3 15.85,45.3 15.2,45.95 11.95,45.95 10.8,44.8 10.8,44.02 J6.B7
A2: length 22.3
  TOP w0.2: U9.33 23.32,50.32 v1(23.05,50.59)
  INNER1 w0.2: J6.B6 15.37,41.41 17.7,43.74 17.7,49.74 18.8,50.85 22.79,50.85 v1(23.05,50.59)
A3: length 23.2
  TOP w0.2: U9.32 22.72,49.82 v1(22.3,50.24)
  INNER1 w0.2: J6.B5 13.4,38.88 18.1,43.58 18.1,49.55 19,50.45 22.09,50.45 v1(22.3,50.24)
A4: length 23.1
  TOP w0.2: v1(23.05,48.84) 25.49,48.84 U9.30
  INNER1 w0.2: J6.B4 13.59,36.34 15.4,38.15 15.4,40.31 18.5,43.41 18.5,46.7 20.7,48.9 23,48.9 v1(23.05,48.84)
A5: length 24.3
  TOP w0.2: U9.29 23.97,48.32 23.8,48.15 21.31,48.15 20.6,47.43 20.6,45.7 20.42,45.52 13.85,38.95 13.85,34.45 13.2,33.8 J6.B3
A6: length 27.6
  TOP w0.2: v1(23.15,47.49) 23.32,47.32 U9.27
  INNER1 w0.2: J6.B2 14.26,31.25 15.8,32.8 15.8,40.15 18.9,43.25 18.9,46.45 19.95,47.5 21.6,47.5 21.61,47.49 v1(23.15,47.49)
A7: length 29
  TOP w0.2: v1(21.35,46.9) 21.4,46.84 25.49,46.84 U9.26
  INNER1 w0.2: v1(21.35,46.9) 19.92,46.9 19.3,46.28 19.3,43.08 16.2,39.98 16.2,31.55 13.37,28.71 J6.B1
A8: length 81.8
  TOP w0.2: U8.47 26.44,74.34 26.7,74.59 26.7,79.54 27.7,80.54 27.7,90.4 27.85,90.54 27.85,91.75 23.3,96.29 3.75,96.29 1.93,94.48 1.93,70.46 4.15,68.25 5.3,68.25 6.73,66.81 J6.B16
A9: length 87.1
  TOP w0.2: J6.B15 6.2,64.28 3.68,66.8 2.45,66.8 1.54,67.71 1.54,94.65 3.58,96.69 23.47,96.69 28.25,91.91 28.25,90.38 28.1,90.23 28.1,80.38 27.1,79.37 27.1,74.09 26.84,73.84 U8.46
A10: length 92.2
  TOP w0.2: J6.B14 10.86,61.74 6.06,61.74 3.91,63.9 2.65,63.9 1.13,65.41 1.13,94.81 3.42,97.09 23.63,97.09 28.65,92.08 28.65,90.21 28.5,90.06 28.5,80.21 27.5,79.21 27.5,73.84 26.49,72.84 U8.44 25.64,72.79
A11: length 98.2
  TOP w0.2: U8.43 26.59,72.34 27.7,73.44 27.7,73.48 27.9,73.68 27.9,79.04 28.9,80.05 28.9,89.9 29.05,90.04 29.05,92.25 23.8,97.5 3.25,97.5 0.73,94.98 0.73,61.41 2.27,59.87 4.07,59.87 4.25,60.05 5.45,60.05 6.3,59.2 J6.B13
A12: length 30.2
  TOP w0.2: v1(27.18,71.29) 27.13,71.34 26.85,71.34 26.84,71.34 U8.41
  INNER1 w0.2: J6.B12 13.16,56.66 13.65,57.15 13.65,64.15 14.2,64.69 18.79,64.69 19.44,65.34 19.72,65.34 21.64,67.27 21.64,70.85 22.19,71.4 24.24,71.4 24.25,71.4 24.75,71.4 24.76,71.4 27.08,71.4 v1(27.18,71.29)
A13: length 28.2
  TOP w0.2: v1(24.5,70.79) 24.55,70.84 25.64,70.84 U8.40
  INNER1 w0.2: v1(24.5,70.79) 24.4,70.69 23.2,70.69 23.05,70.55 23.05,69.49 22.2,68.64 22.2,67.26 20,65.06 20,63.05 18.5,61.55 14.35,61.55 14.05,61.24 14.05,54.7 13.47,54.12 J6.B11
A14: length 29.6
  TOP w0.2: v1(24.3,69.99) 24.31,69.99 24.46,69.84 U8.38
  INNER1 w0.2: J6.B10 14.08,51.58 14.45,51.95 14.45,60.84 14.75,61.15 18.67,61.15 20.4,62.88 20.4,64.9 22.7,67.19 22.7,68.5 23.05,68.85 23.16,68.85 v1(24.3,69.99)
A15: length 33
  TOP w0.2: v1(26.9,69.34) 26.89,69.34 U8.37
  INNER1 w0.2: v1(26.9,69.34) 25.42,69.34 20.8,64.73 20.8,62.72 18.83,60.74 15.05,60.74 14.85,60.55 14.85,50.15 13.75,49.05 10.88,49.05 J6.B9
A16: length 24.1
  TOP w0.2: U6.36 24.84,85.6 24.83,85.61 24.03,85.61 23.54,86.09 23.54,86.6 23.55,86.6 23.55,88.15 21.95,89.75 21.95,91.68 21.95,91.68 21.95,92.01 20.71,93.25 16.52,93.25 12.9,89.63 12.9,87.79 12.24,87.13 J6.B24
A17: length 25.4
  TOP w0.2: U6.35 24.6,85.1 24.55,85.15 23.92,85.15 23.14,85.93 23.14,87.99 21.55,89.58 21.55,91.84 20.54,92.85 16.69,92.85 13.3,89.46 13.3,87.5 11.77,85.96 11.77,85.5 J6.B23
A18: length 93.9
  TOP w0.2: U6.33 24.74,84.1 v1(24.3,84.54) 23.8,84.54 22.74,85.6 22.74,87.82 21.15,89.42 21.15,91.68 20.38,92.45 16.85,92.45 13.7,89.3 13.7,83.36 12.39,82.06 J6.B22 ; U7.6 17.78,33.27 18.1,33.59 v1(18.1,33.64)
  INNER2 w0.2: v1(24.3,84.54) 26.14,82.7 26.14,79.77 24.97,78.59 23.5,78.59 22.3,77.39 22.3,72.22 21.6,71.53 21.6,68.79 29.2,61.2 29.2,42.38 20.41,33.59 18.15,33.59 v1(18.1,33.64)
A19: length 94.3
  TOP w0.2: U6.32 25.6,83.65 v1(24.3,83.65) 24.13,83.65 22.34,85.43 22.34,87.66 20.75,89.25 20.75,91.51 20.21,92.05 17.02,92.05 14.1,89.13 14.1,80.34 13.27,79.51 J6.B21 ; v1(18,34.54) U7.5
  INNER2 w0.2: v1(24.3,83.65) 25.74,82.2 25.74,79.94 24.8,79 23.34,79 21.9,77.56 21.9,72.39 21.2,71.7 21.2,68.96 21.2,68.95 21.2,68.62 28.8,61.03 28.8,42.54 21.15,34.9 19.2,34.9 18.84,34.54 v1(18,34.54)
A20: length 80.6
  TOP w0.2: v1(18.74,35.84) 16.67,35.84 U7.4 ; v1(24.05,82.7) 24.05,82.69 24.15,82.59 25.64,82.59 U6.30
  INNER1 w0.2: v1(24.05,82.7) 23.59,82.25 18.15,82.25 17.5,82.9 16.1,82.9 14.6,81.4 11.54,81.4 10.02,79.87 10.02,79.16 10.87,78.31 J6.B20
  INNER2 w0.2: v1(18.74,35.84) 18.74,37.5 20.15,38.9 24.02,38.9 28,42.88 28,58.51 20.4,66.11 20.4,68.29 20.4,68.29 20.4,68.96 20.4,69.29 20.4,69.29 20.4,72.03 21.1,72.72 21.1,77.89 23.8,80.59 23.8,81.28 23.49,81.59 23.49,82.15 v1(24.05,82.7)
A21: length 79.9
  TOP w0.2: 16.64,37.08 16.7,37.15 19.25,37.15 v1(20.4,38.3) ; U6.29 25.64,82.09 24.35,82.09 v1(24.1,81.84)
  INNER1 w0.2: v1(24.1,81.84) 17.98,81.84 17.38,82.44 16.22,82.44 14.77,81 14.75,81 13.1,79.35 12.26,79.35 11.77,78.85 11.77,75.34 J6.B19
  INNER2 w0.2: v1(24.1,81.84) 24.15,81.84 25.02,80.98 25.02,79.85 24.56,79.4 23.17,79.4 21.5,77.72 21.5,72.56 20.8,71.86 20.8,69.12 20.8,68.46 20.8,68.46 20.8,66.27 28.4,58.68 28.4,42.71 23.98,38.3 v1(20.4,38.3)
A22: length 83.3
  TOP w0.2: U7.2 14.51,38.35 v1(14.5,38.34) ; U6.27 23.46,81.1 v1(23.2,80.84)
  INNER1 w0.2: v1(23.2,80.84) 22.6,81.44 18.2,81.44 17.9,81.15 17.01,81.15 17,81.15 16.5,81.15 16.14,80.8 16.14,80.79 15.6,80.25 14.73,80.25 13.64,79.16 13.64,78.31 13.24,77.91 13.24,77.03 13.25,77.02 13.25,76.53 14,75.78 14,72.56 13.33,71.9 J6.B18
  INNER2 w0.2: v1(14.5,38.34) 19,38.34 19.96,39.3 23.86,39.3 27.6,43.04 27.6,58.35 20,65.94 20,68.12 20,68.13 20,69.12 20,69.12 20,69.45 20,72.19 20.7,72.89 20.7,78.34 v1(23.2,80.84)
A23: length 27.2
  TOP w0.2: U6.26 25.69,80.65 v1(26.95,80.65)
  INNER1 w0.2: J6.B17 10.87,70.06 12.02,71.22 13.22,71.22 14.4,72.4 14.4,75.94 13.65,76.69 13.65,77.19 13.64,77.19 13.64,77.74 14.04,78.14 14.04,79 14.9,79.85 17.1,79.85 17.4,80.15 23.4,80.15 23.96,80.71 26.89,80.71 v1(26.95,80.65)
AEN/: length 12.6
  TOP w0.2: 16.64,32 16.56,31.93 11.39,31.93 10.58,32.75 10.25,32.75 9.15,33.84 4.92,33.84 J6.E3
BRD/: length 21.5
  TOP w0.2: U48.7 16.67,16.8 19.5,16.8 22.1,19.39 22.1,30.14 22.69,30.73 U7.13
BRESET: length 21.4
  TOP w0.2: U7.12 26,29.5 23.05,29.5 22.5,28.95 22.5,18.34 19.65,15.49 U48.8
BUF_OUT: length 1.4
  TOP w0.5: R50.1 C41.2
BWR/: length 21.3
  TOP w0.2: U48.6 18.94,18.03 21.7,20.8 21.7,31.14 22.6,32.05 25.99,32.05 26.04,32
CENTER-TAP: length 2
  TOP w0.5: R21.2 C41.1
CLKC: length 85.9
  TOP w0.102: U1.C3 52.9,72.94 v2(55.2,72.94)
  INNER1 w0.1: 55.59,73 55.25,73 v2(55.2,72.94)
  INNER1 w0.2: 55.59,73 64.8,73 66.74,71.05 66.74,70.94 67.1,70.59 67.21,70.59 69.8,68 82.25,68 83.2,67.05 83.2,56.9 80.8,54.49 80.8,23.05 v1(76.92,19.16)
  BOTTOM w0.2: R26.1 v1(76.92,19.16)
CLOCK+: length 57.9
  TOP w0.1: U2.J11 61.97,47.4 62.2,47.16 v2(62.2,47.05) ; U1.H4 51.6,78.44 v2(51.9,78.15)
  TOP w0.127: U50.31 67.92,35.5 68.35,35.5 68.43,35.42 69.27,35.42 69.75,35.89 69.75,37.32 v1(69.47,37.59)
  INNER1 w0.1: v2(51.9,78.15) 51.48,78.15 51.25,77.91 51.25,75.75 55.39,71.61 55.39,71.59 55.41,71.58 ; 59.01,56.41 59.01,56.39 59.02,56.38 59.02,48.05 59.79,47.28 61.9,47.28 62,47.27 v2(62.2,47.05) 62.48,47.05 62.5,47.02 63.25,47.02 64.18,46.09 67.47,46.09 67.75,45.82 67.75,45.8 67.77,45.78
  INNER1 w0.127: 59.01,56.41 59.01,63.75 56.45,66.32 56.45,70.54 55.41,71.58 ; 67.77,45.78 68.1,45.45 68.1,41.84 69.75,40.2 69.75,37.87 v1(69.47,37.59)
CLOCK-: length 59.5
  TOP w0.1: v2(62.25,47.7) 62.25,47.55 62.4,47.4 U2.J12 ; U1.H3 52.2,78.44 v2(51.9,78.75)
  TOP w0.127: v1(70.28,37.59) 70,37.32 70,35.79 69.38,35.16 68.42,35.16 68.35,35.09 67.94,35.09 U50.30
  INNER1 w0.1: 67.94,45.96 67.93,45.98 67.91,45.98 67.56,46.32 64.27,46.32 63.35,47.24 62.6,47.24 62.25,47.59 v2(62.25,47.7) 62.02,47.5 61.92,47.51 59.89,47.51 59.25,48.15 59.25,56.38 59.26,56.39 59.26,56.41 ; v2(51.9,78.75) 51.9,78.74 52.3,78.33 52.3,78 52.05,77.75 51.48,77.75 51.48,75.85 55.55,71.77 55.57,71.77 55.59,71.76
  INNER1 w0.127: 67.94,45.96 68.35,45.55 68.35,41.95 70,40.3 70,37.87 v1(70.28,37.59) ; 59.26,56.41 59.26,63.86 56.7,66.42 56.7,70.65 55.59,71.76
CONF_SW0: length 40.5
  TOP w0.102: U1.T11 v2(43.9,86.94)
  TOP w0.2: v1(61.75,79.19) 61.75,79.4 62.5,80.15 62.5,84.59 64.15,86.25 66.51,86.25 SW1.1
  INNER1 w0.102: 55.59,80.34 44.96,80.34 43.34,81.97 43.34,86.38 v2(43.9,86.94)
  INNER1 w0.2: v1(61.75,79.19) 61.2,79.19 61.2,79.2 60.39,79.2 59.5,80.09 55.88,80.09 55.63,80.34 55.59,80.34
  BOTTOM w0.2: v1(61.75,79.19) 62,78.94 RN1.1
CONF_SW1: length 34.7
  TOP w0.102: U1.R11 v2(43.9,85.94)
  TOP w0.2: SW1.2 63.95,83.69 63.25,83 63.25,82.15 63.24,82.15 63.24,81.64 63.25,81.64 v1(63.25,80.65) 63.25,80.63
  INNER1 w0.102: 55.59,81.29 55.54,81.34 44.3,81.34 43.52,82.13 43.52,85.56 v2(43.9,85.94)
  INNER1 w0.2: v1(63.25,80.65) 63.25,80.63 63.11,80.49 61.23,80.49 60.42,81.29 55.59,81.29
  BOTTOM w0.2: v1(63.25,80.65) 63.67,80.22 63.67,80.07 64.4,79.34 RN1.2
CONF_SW2: length 24.2
  TOP w0.102: U1.N8 v2(47.9,83.94)
  TOP w0.2: v1(64.5,80.34) 64.54,80.39 64.54,80.84 64.85,81.15 SW1.3
  INNER1 w0.102: 55.59,82.09 55.4,82.09 55.17,82.33 49.52,82.33 v2(47.9,83.94)
  INNER1 w0.2: 55.59,82.09 64.05,82.09 64.5,81.65 v1(64.5,80.34)
  BOTTOM w0.2: RN1.3 65.1,79.75 v1(64.5,80.34)
CONF_SW3: length 26.4
  TOP w0.102: U1.M9 v2(46.88,81.97)
  TOP w0.2: v1(63.85,81.4) 63.85,81.4 63.85,79.34 64.65,78.54 66.45,78.54 SW1.4
  INNER1 w0.102: v2(46.88,81.97) 47.3,81.54 55.44,81.54 55.59,81.69
  INNER1 w0.2: 63.85,81.4 v1(63.85,81.4) 63.1,81.4 62.59,80.88 61.4,80.88 60.59,81.69 55.59,81.69
  BOTTOM w0.2: v1(63.85,81.4) 64.7,81.4 65.95,80.15 RN1.4
D0: length 36.5
  TOP w0.2: v1(23.45,52.4) 23.52,52.32 U9.37 ; U8.26 25.6,63.8 24.4,63.8 v1(24.3,63.7)
  INNER2 w0.2: J6.E8 9.5,46.49 10.95,47.95 11.15,47.95 12.35,49.15 14,49.15 15.1,50.24 17.8,50.24 18.4,50.84 21.9,50.84 v1(23.45,52.4)
  BOTTOM w0.2: v1(23.45,52.4) 23.45,52.99 24.7,54.24 24.7,63.29 v1(24.3,63.7)
