# Allegro board fillets.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDX1: length 127.4
  TOP w0.2: U48.12 v1(27.42,14.22) ; v1(67.66,4.37) U38.8 69.12,4.35 70.95,4.35 73.2,6.6 73.2,14.64 71.53,16.31 67.92,16.31 67.15,17.08 67.15,19 68,19.85 U39.8 73.35,19.85 76.85,23.34 76.85,29.46 78.48,31.09 92.15,31.09 97.75,36.7 100.12,36.7 U22.8 100.18,36.7 v1(101.95,36.7)
  INNER1 w0.2: v1(67.66,4.37) 66.84,3.55 32.4,3.55 28.1,7.85 28.1,13.54 v1(27.42,14.22)
  BOTTOM w0.2: RN2.6 102.52,37.27 v1(101.95,36.7) 99.2,36.7 96.6,34.09 R6.2
VDX2: length 127.2
  TOP w0.2: v1(67.66,5.64) U38.7 69.1,5.65 70.85,5.65 72.8,7.6 72.8,14.47 71.37,15.91 67.76,15.91 66.75,16.91 66.75,19.45 68.42,21.12 U39.7 69.12,21.09 72.95,21.09 76.45,24.59 76.45,29.63 78.32,31.5 91.2,31.5 97.65,37.94 U22.7 100.16,37.95 v1(102.05,37.95) ; U48.13 v1(27.42,15.49)
  INNER1 w0.2: v1(67.66,5.64) 65.97,3.95 32.57,3.95 28.5,8.02 28.5,14.41 v1(27.42,15.49)
  BOTTOM w0.2: RN2.7 102.33,37.66 v1(102.05,37.95) 98.4,37.95 96.6,36.14 R4.2
VDX3: length 128.1
  TOP w0.2: U48.14 v1(27.42,16.76) ; v1(102.25,38.84) 101.9,39.2 100.16,39.2 U22.6 100.12,39.24 97.8,39.24 90.45,31.89 78.15,31.89 76.05,29.79 76.05,25.3 73.14,22.39 U39.6 69,22.3 67.95,22.3 66.35,20.7 66.35,16.75 67.59,15.51 71.2,15.51 72.4,14.31 72.4,8.71 70.6,6.91 U38.6 v1(67.66,6.91)
  INNER1 w0.2: v1(27.42,16.76) 28.9,15.28 28.9,8.18 32.74,4.35 65.1,4.35 v1(67.66,6.91)
  BOTTOM w0.2: R2.2 96.6,38.24 97.2,38.84 v1(102.25,38.84) 103.03,38.06 RN2.8
VDX4: length 128.1
  TOP w0.2: v1(101.5,40.45) 100.19,40.45 U22.5 100.13,40.49 98.15,40.49 89.95,32.3 77.99,32.3 75.65,29.96 75.65,26 73.31,23.66 U39.5 67.71,23.66 65.95,21.89 65.95,16.58 67.42,15.11 71.04,15.11 72,14.14 72,9.7 70.48,8.18 U38.5 v1(67.66,8.18) ; U48.15 v1(27.42,18.03)
  INNER1 w0.2: v1(67.66,8.18) 64.23,4.75 32.9,4.75 29.3,8.35 29.3,16.15 v1(27.42,18.03)
  BOTTOM w0.2: R7.2 101.2,40.15 v1(101.5,40.45) 103,41.95 RN3.5
VDX5: length 128.8
  TOP w0.2: U48.16 v1(27.42,19.3) ; v1(101.5,41.74) 100.16,41.74 U22.4 98.81,41.75 89.75,32.7 77.82,32.7 75.25,30.12 75.25,26.84 73.25,24.84 69.18,24.84 U39.4 69.08,24.95 67.35,24.95 65.55,23.14 65.55,16.41 67.26,14.71 70.87,14.71 71.6,13.98 71.6,10.64 70.4,9.45 U38.4 v1(67.66,9.45)
  INNER1 w0.2: v1(27.42,19.3) 29.7,17.02 29.7,8.51 33.07,5.15 63.36,5.15 v1(67.66,9.45)
  BOTTOM w0.2: RN3.6 102.1,42.34 v1(101.5,41.74) 101,42.24 R5.2
VDX6: length 130.1
  TOP w0.2: v1(67.66,10.72) U38.3 70.25,10.72 71.2,11.67 71.2,13.81 70.7,14.31 67.09,14.31 65.15,16.25 65.15,24.55 66.8,26.2 U39.3 73.4,26.2 74.85,27.64 74.85,30.29 77.65,33.09 88.35,33.09 98.3,43.05 100.12,43.05 100.15,43.02 100.18,43.05 v1(101.5,43.05) ; U48.17 v1(27.42,20.57)
  INNER1 w0.2: v1(27.42,20.57) 30.1,17.89 30.1,8.68 33.23,5.54 62.49,5.54 v1(67.66,10.72)
  BOTTOM w0.2: R3.2 96.6,44.15 97.7,43.05 v1(101.5,43.05) 101.8,42.74 RN3.7
VDX7: length 131.5
  TOP w0.2: U48.18 v1(27.42,21.84) ; v1(101.45,44.3) 100.16,44.3 U22.2 98.98,44.29 88.18,33.5 77.49,33.5 74.45,30.46 74.45,28.3 73.62,27.47 U39.2 69.07,27.5 66.9,27.5 64.75,25.34 64.75,16.08 66.93,13.91 70.54,13.91 70.8,13.64 70.8,12.6 70.19,11.99 U38.2 v1(67.66,11.99)
  INNER1 w0.2: v1(67.66,11.99) 61.62,5.95 33.4,5.95 30.5,8.85 30.5,18.76 v1(27.42,21.84)
  BOTTOM w0.2: R1.2 96.6,46.24 98.55,44.3 v1(101.45,44.3) 102.6,43.15 RN3.8
VTTREF: length 2.5
  TOP w0.2: v1(75.15,33.14) 74.75,33.54 U51.6
  BOTTOM w0.2: v1(75.15,33.14) 76.44,33.14 C2016.1
WAIT/: length 17.8
  TOP w0.2: U48.2 15.13,23.11 13.7,24.55 7.05,24.55 5.72,25.88 5.72,30.41 J6.E2
N00286: length 10.2
  TOP w0.5: L6.1 100.98,78.47 C35.1 103.54,78.37 L5.2 106.68,78.46 106.68,78.23 ; 106.68,78.23 C38.1 ; 106.68,78.23 C34.1
N00395: length 6.4
  TOP w0.5: C35.2 99.97,76.56 L6.2 97.77,77.47 R17.1 97.52,75.53 C37.2
N00671: length 2
  BOTTOM w0.2: R1.1 C3.1
N00689: length 2
  BOTTOM w0.2: C5.1 R3.1
N00703: length 2
  BOTTOM w0.2: R5.1 C7.1
N00717: length 2
  BOTTOM w0.2: C9.1 R7.1
N00827: length 2
  BOTTOM w0.2: R2.1 C4.1
N00831: length 2
  BOTTOM w0.2: C6.1 R4.1
N00835: length 2
  BOTTOM w0.2: R6.1 C8.1
N00837: length 2
  BOTTOM w0.2: C10.1 R8.1
N04966: length 18.5
  TOP w0.2: v1(98.1,21.55) 96.8,21.55 L9.1 ; v1(98.1,5.95) 98.1,5.94 L7.1
  INNER1 w0.2: v1(98.1,21.55) v1(98.1,5.95)
N15853: length 42.1
  TOP w0.102: U2.T7 v2(57.25,39.9) ; U12.K9 v2(35.9,54.24)
  INNER1 w0.102: v2(35.9,54.24) 35.9,52.8 35.52,52.41 35.52,40.76 34.9,40.15 34.9,38.74 35.6,38.05 52.85,38.05 53.55,37.34 56.3,37.34 56.55,37.59 56.55,37.95 57.25,38.65 v2(57.25,39.9)
N15863: length 26.4
  TOP w0.102: U2.R7 v2(57.25,40.9) ; U13.K9 v2(35.9,40.45)
  INNER1 w0.102: v2(57.25,40.9) 57.25,40.84 56.7,40.3 56.7,38.98 55.97,38.24 36.57,38.24 36.02,38.79 36.02,38.88 35.85,39.05 35.85,40.4 v2(35.9,40.45)
N15891: length 29.6
  TOP w0.102: U12.B3 v2(43.1,59.84) ; U2.M7 v2(57.25,43.9)
  INNER2 w0.102: v2(57.25,43.9) 57.85,44.49 57.85,45.09 57.47,45.48 56.2,45.48 55.88,45.8 55.88,46.11 55.52,46.48 54.13,46.48 53.83,46.77 53.83,47.12 53.16,47.8 52.55,47.8 52.01,48.33 52.01,48.34 51.81,48.55 51.81,53.23 51.55,53.49 51,53.49 50.87,53.36 44.83,53.36 44.65,53.55 44.65,57.65 44.05,58.24 44.05,58.9 v2(43.1,59.84)
N15907: length 48.7
  TOP w0.102: U12.F3 v2(39.9,59.84) ; U2.P6 v2(56.25,41.9)
  INNER1 w0.102: v2(56.25,41.9) 55.85,42.3 54.71,42.3 51.66,39.24 38.45,39.24 37.66,40.03 37.66,42.59 37.26,42.99 37.26,46.4 37.07,46.59 37.07,48.67 37.66,49.26 37.66,52.49 37.33,52.82 37.33,56.08 37.8,56.55 37.8,61.59 38.05,61.84 40.1,61.84 40.32,61.63 40.32,60.26 v2(39.9,59.84)
N15924: length 19.5
  TOP w0.102: U13.F3 v2(39.9,46.05) ; U2.N6 v2(56.25,42.9)
  INNER2 w0.102: v2(39.9,46.05) 40.55,45.4 44.75,45.4 45.45,46.09 49.4,46.09 51,44.49 51.45,44.49 51.65,44.3 52.4,44.3 53.42,43.28 55.87,43.28 v2(56.25,42.9)
N15963: length 16.7
  TOP w0.102: U13.B3 v2(43.1,46.05) ; U2.L7 v2(57.25,44.9)
  INNER2 w0.102: v2(57.25,44.9) 56.79,44.9 56.41,44.51 51.73,44.51 51.55,44.7 51.1,44.7 50.23,45.57 50.22,45.57 49.51,46.28 45.03,46.28 44.4,45.65 43.5,45.65 v2(43.1,46.05)
N16041: length 40.6
  TOP w0.102: U13.J8 v2(36.7,41.24) ; U2.T5 v2(55.25,39.9) ; U12.J8 v2(36.7,55.05)
  INNER1 w0.102: v2(36.7,41.24) 37.1,40.84 37.1,39.74 38.2,38.65 54,38.65 v2(55.25,39.9)
  INNER2 w0.1: 37.3,45.65 36.48,44.83 36.48,42.62 36.32,42.46 36.32,41.62 v2(36.7,41.24) ; 36.65,48.2 36.64,48.2 36.64,48.25 36.25,48.65 34.65,48.65 34.3,48.99 34.3,52.8 35.35,53.84 36.15,53.84 36.3,53.99 36.3,54.55 36.7,54.95 v2(36.7,55.05)
  INNER2 w0.102: 36.65,48.2 36.65,46.99 37.3,46.34 37.3,45.65
N16054: length 41.1
  TOP w0.102: U12.K8 v2(35.9,55.05) ; U2.R5 v2(55.25,40.9) ; U13.K8 v2(35.9,41.24)
  INNER1 w0.102: v2(35.9,41.24) 36.3,40.84 36.3,39.7 37.55,38.45 54.9,38.45 55.7,39.24 55.7,40.45 v2(55.25,40.9)
  BOTTOM w0.102: v2(35.9,55.05) 35.52,54.66 35.52,54.09 35.7,53.91 35.7,53.09 34.9,52.3 34.9,48.09 34.7,47.9 34.7,47.4 34.85,47.24 35.24,47.24 35.48,47 35.48,46.96 35.5,46.95 35.5,44.3 36.28,43.51 36.28,41.63 v2(35.9,41.24)
N16064: length 43.4
  TOP w0.102: U13.K2 35.9,46.84 v2(35.9,47.65) ; U2.T4 v2(54.25,39.9) ; U12.K2 v2(35.9,60.65)
  INNER1 w0.102: v2(35.9,47.65) 35.9,46.84 U13.K2 36.3,43.09 37.3,42.09 37.3,39.84 38.3,38.84 53.2,38.84 v2(54.25,39.9)
  BOTTOM w0.1: 37.15,53.99 36.46,53.31 36.46,53.3 35.28,52.12 35.28,48.31 35.9,47.7
  BOTTOM w0.102: 35.9,47.7 v2(35.9,47.65) ; 37.15,53.99 37.15,58.74 36.3,59.59 U12.K2 v2(35.9,60.65)
N16300: length 38.1
  TOP w0.102: U2.P5 v2(55.25,41.9) ; U12.L8 v2(35.1,55.05)
  INNER1 w0.102: v2(35.1,55.05) 35.48,54.66 36.88,54.66 37.15,54.4 37.15,52.74 37.48,52.41 37.48,49.34 36.85,48.71 36.85,46.49 37.08,46.26 37.08,42.91 37.48,42.51 37.48,39.92 38.38,39.03 51.7,39.03 54,41.33 54.7,41.33 55.25,41.88 v2(55.25,41.9)
N16316: length 25.2
  TOP w0.102: U13.L8 v2(35.1,41.24) ; U2.N5 v2(55.25,42.9)
  BOTTOM w0.102: v2(55.25,42.9) 54.7,42.34 54.7,42.09 54.05,41.45 52.05,41.45 51.81,41.68 51.81,42.13 51.48,42.46 51.02,42.46 50.5,41.94 50.5,41.2 49.25,39.95 35.8,39.95 35.1,40.65 v2(35.1,41.24)
N16670: length 45.6
  TOP w0.102: U13.K3 v2(35.9,46.05) ; U12.K3 v2(35.9,59.84) ; U2.P8 v2(58.25,42.9)
  INNER2 w0.102: v2(35.9,46.05) 35.9,46.95 35.5,47.34 35.5,47.92 35.4,48.03 34.33,48.03 33.68,48.67 33.68,53.05 34.88,54.24 34.88,54.72 34.72,54.89 34.72,56.33 33.9,57.15 33.9,59.99 34.15,60.24 35.5,60.24 v2(35.9,59.84)
  BOTTOM w0.102: v2(58.25,42.9) 57.85,43.29 51.87,43.29 51.65,43.51 50.07,43.51 49.6,43.05 48.76,43.05 48.75,43.05 47.05,43.05 47.04,43.05 37.15,43.05 35.9,44.3 v2(35.9,46.05)
N16714: length 45.7
  TOP w0.1: U2.P7 57.75,41.9 58.1,41.54 58.1,39.97 57.45,39.31 46.99,39.31 46.09,40.21 46.09,40.95 44.05,42.99 36.9,42.99 36.35,42.45 U13.K7
  TOP w0.102: U12.K7 v2(35.9,55.84) ; v2(35.9,42.05) U13.K7
  INNER2 w0.102: v2(35.9,42.05) 35.9,42.3 36.3,42.7 36.3,44.95 37.1,45.74 37.1,46.24 36.46,46.88 36.46,48.13 36.15,48.45 34.55,48.45 34.1,48.9 34.1,52.9 35.45,54.24 35.45,54.4 35.7,54.65 36.08,54.65 36.28,54.84 36.28,55.46 v2(35.9,55.84)
N16747: length 37.4
  TOP w0.1: U2.T3 52.85,39.49 47.06,39.49 46.27,40.29 46.27,41.02 44.1,43.2 36.25,43.2 v2(35.9,42.84)
  TOP w0.102: U12.L7 v2(35.1,55.84) ; U13.L7 v2(35.9,42.84)
  INNER2 w0.102: v2(35.9,42.84) 36.1,43.05 36.1,45.15 36.28,45.33 36.28,48.01 36.05,48.24 34.45,48.24 33.9,48.8 33.9,53 35.18,54.28 35.18,54.43 35.5,54.74 35.5,55.45 v2(35.1,55.84)
N17275: length 32.3
  TOP w0.1: U12.B7 43.45,56.99 50.83,56.99 ; 59.23,56.41 59.3,56.34 59.3,42.3 59.75,41.84 U2.R9
  TOP w0.2: 59.23,56.41 58.65,56.99 50.83,56.99
N17319: length 29.6
  TOP w0.102: U12.A8 v2(43.9,55.05) ; v2(59.25,41.7) 59.25,40.9 U2.T9
  INNER2 w0.102: v2(59.25,41.7) 58.95,41.99 58.95,42.8 58.35,43.4 57,43.4 56.75,43.65 56.75,44.2 57,44.45 57.4,44.45 57.63,44.68 57.63,45.05 57.39,45.3 56.1,45.3 55.7,45.7 55.7,45.99 55.4,46.3 54.05,46.3 53.65,46.7 53.65,47.05 53.1,47.59 52.45,47.59 51.63,48.41 51.63,53.11 51.45,53.3 51.1,53.3 50.95,53.15 44.75,53.15 44.45,53.45 44.45,54.49 v2(43.9,55.05)
N17344: length 21.8
  TOP w0.102: U2.N9 v2(60.25,42.9) ; U13.A8 v2(43.9,41.24)
  INNER2 w0.102: v2(60.25,42.9) 60.25,42.84 60.65,42.45 60.65,41.7 60.05,41.09 59.1,41.09 58.5,40.49 53,40.49 51.93,39.43 44.42,39.43 44.28,39.56 44.28,40.86 v2(43.9,41.24)
N17369: length 19.3
  TOP w0.102: U13.B7 v2(43.1,42.05) ; U2.P9 v2(60.25,41.9)
  INNER2 w0.1: 49.5,41.95 50.15,41.3 59.65,41.3 v2(60.25,41.9)
  INNER2 w0.102: 49.5,41.95 44.54,41.95 44.06,42.43 43.48,42.43 v2(43.1,42.05)
N17394: length 41.9
  TOP w0.102: U12.F7 v2(39.9,55.84) ; U2.M6 v2(56.25,43.9)
  INNER1 w0.1: v2(39.9,55.84) 39.45,56.3
  INNER1 w0.102: v2(56.25,43.9) 55.8,43.45 55.8,42.7 55.6,42.49 54.65,42.49 51.6,39.45 38.55,39.45 37.85,40.15 37.85,42.66 37.45,43.07 37.45,45.09 37.9,45.54 37.9,48.59 38.5,49.2 38.5,52.13 38.26,52.38 38.08,52.38 37.51,52.95 37.51,55.96 37.85,56.3 39.45,56.3
N17449: length 20.3
  TOP w0.102: U13.F7 v2(39.9,42.05) ; U2.T6 v2(56.25,39.9)
  INNER2 w0.102: v2(39.9,42.05) 40.28,41.66 40.28,40.06 41.1,39.24 52.06,39.24 53.09,40.28 55.41,40.28 55.79,39.9 v2(56.25,39.9)
N44457: length 25.7
  TOP w0.102: U1.K6 v2(49.9,80.94)
  TOP w0.2: v1(61,68.75) 61.65,68.1 62.89,68.1
  INNER2 w0.1: 55.59,81.15 55.54,81.15 55.36,81.32 50.28,81.32 v2(49.9,80.94)
  INNER2 w0.2: 55.59,81.15 57.93,81.15 61.85,77.23 61.85,69.29 61.3,68.75 v1(61,68.75)
N44464: length 26.1
  TOP w0.1: U1.K3 52.8,80.84 55.23,80.84 55.59,80.49
  TOP w0.2: 68.69,68.1 66.75,68.1 65.75,69.09 65.75,70.59 65,71.34 62.89,71.34 U10.3 61.6,71.35 61.25,71.69 61.25,72.44 60.5,73.19 57.75,73.19 56.85,74.09 56.85,79.23 55.59,80.49
N44478: length 15
  TOP w0.102: U1.E2 v2(53.9,74.94)
  TOP w0.2: v1(61.05,69.59) 61.3,69.59 61.84,69.06 61.84,69.05 62.14,68.75 U10.7
  INNER2 w0.1: 55.59,74.94 v2(53.9,74.94)
  INNER2 w0.2: v1(61.05,69.59) 61.05,74.29 60.4,74.94 55.59,74.94
N44485: length 25.5
  TOP w0.102: U1.L4 v2(51.9,81.94)
  TOP w0.2: v1(61.1,67.5) 61.8,66.8 62.89,66.8
  INNER2 w0.1: v2(51.9,81.94) 52.3,81.54 55.59,81.54
  INNER2 w0.2: 55.59,81.54 58.1,81.54 62.35,77.29 62.35,68.75 v1(61.1,67.5)
N44490: length 21.4
  TOP w0.1: 55.59,81.06 55.57,81.07 53.22,81.07 52.9,81.4 52.9,82.59 52.6,82.9 51.15,82.9 50.85,82.59 50.85,81.9 U1.L5
  TOP w0.2: U10.1 61.65,72.65 60.7,73.59 57.95,73.59 57.25,74.29 57.25,79.4 55.59,81.06
N45317: length 26.9
  TOP w0.102: U2.M11 v2(62.25,43.9)
  TOP w0.2: U11.1 80.62,48.8 v1(81.95,48.8)
  BOTTOM w0.102: v2(62.25,43.9) 62.25,43.7 63.43,42.51 67.6,42.51 67.75,42.66 67.94,42.66
  BOTTOM w0.2: 67.94,42.66 78.92,42.66 81.95,45.69 v1(81.95,48.8)
N61996: length 1.7
  TOP w0.5: C71.1 103.49,80.26 R50.2
N62056: length 7.3
  TOP w0.5: R46.1 97.54,85.35 R51.1 98.88,86.19 100.9,86.19 101.53,86.83 Q8.1
N62230: length 7.8
  TOP w0.5: R48.1 102.47,84.09 R49.1 C71.2 107.17,81.92 Q9.1
N62316: length 3.2
  TOP w0.5: 100.6,83.56 100.21,83.56 C72.2 ; 100.6,83.56 100.6,84.95 Q8.3 ; 100.6,83.56 R48.2
N62436: length 5
  TOP w0.5: R46.2 95.5,86.84 94.1,86.84 92.84,88.1 D5.3
N62564: length 13.7
  TOP w0.5: R47.1 101.69,89.79 C69.1 107.33,89.79 Q9.3 109.96,88.13 C70.1
N68133: length 7.7
  TOP w0.5: R23.2 92.69,83.32 Q3.1 ; R23.2 92.69,79.04 C42.2 ; R23.2 R21.1
N70364: length 6.4
  TOP w0.5: Q3.2 C43.2 88.43,82.75 R24.2
N80550: length 2.3
  TOP w0.5: R19.1 88.39,87.38 C40.2
N81780: length 1.9
  TOP w0.5: R49.2 C69.2
N84247: length 41.7
  TOP w0.2: U8.9 18.04,70.84 17.16,70.84 17.06,70.94 16.56,70.94 16.46,70.84 v1(16.15,70.84) 16.15,70.15 16.96,69.34 U8.12 ; v1(15.87,48.32) 16.33,48.32 16.44,48.42 16.94,48.42 17.04,48.32 U9.20 ; v1(16.75,80.54) 16.75,80.63 17.22,81.1 U6.22
  BOTTOM w0.2: v1(15.87,48.32) 15.3,48.9 15.3,51.09 15.29,51.09 15.29,51.6 15.3,51.6 15.3,57.05 16.15,57.9 v1(16.15,70.84) 16.15,79.94 v1(16.75,80.54)
N103899: length 46.5
  TOP w0.2: U6.23 18.05,80.59 19.05,80.59 19.29,80.84 v1(19.3,80.84) 19.3,82.4 19.09,82.6 U6.19 ; U8.11 18.05,69.84 19.15,69.84 19.29,69.99 v1(19.29,71.34) U8.8 ; U9.23 18.75,46.82 18.95,47.02 18.95,48.05 19.2,48.3 v1(19.2,48.84) 17.94,48.84 U9.19
  INNER2 w0.2: v1(19.29,71.34) 18.79,71.84 18.79,80.33 v1(19.3,80.84)
  BOTTOM w0.2: v1(19.29,71.34) 19.31,71.34 20,70.64 20,58.9 18.1,56.99 18.1,49.95 v1(19.2,48.84)
N108857: length 2.7
  TOP w0.2: U4.21 v1(79.54,62.3)
  BOTTOM w0.5: v1(79.54,62.3) 78.25,62.3 R12.2
N108997: length 5.3
  TOP w0.2: U4.12 v1(72.34,59.7)
  BOTTOM w0.2: v1(72.34,59.7) 76.16,59.7 R14.2
N111502: length 5.1
  TOP w0.5: 36.5,21.08 36.5,19.75 37.11,19.14 C11.1 ; 36.5,21.08 36.38,20.96 U3.1 ; 36.5,21.08 C12.2
N111881: length 28.6
  TOP w0.5: C13.2 40.61,19.14 ; 40.61,19.14 40.61,18.34 40.89,18.05 40.89,18.03 41.2,17.73 41.2,11.89 42.5,10.6 49,10.6 49.5,10.1 49.5,9 51.05,7.45 R10.2 ; 40.61,19.14 C11.2 39.34,20.84 R11.1 39.41,22.8 C14.2 39.36,23.15 R9.2
N113142: length 5
  TOP w0.5: L4.1 45.05,24.04 44.21,24.88 C15.2 41.46,24.88 R9.1
N114006: length 10.3
  TOP w0.5: C20.1 58.75,5.5 Q1.1 55.75,5.5 55,4.75 55,3.53 R13.2 52.88,3.5 C18.1 52.53,5.92 R10.1
N118214: length 28.8
  TOP w0.5: C19.1 41.8,1.3 v1(40.8,1.3) ; L3.3 48.58,12.07 50.25,10.39 50.25,9.68 51.39,8.54 54.1,8.54 54.95,7.7 Q1.3
  BOTTOM w0.5: L3.3 44.63,12.04 42.65,12.04 40.8,10.2 v1(40.8,1.3)
N118917: length 6.7
  TOP w0.5: R11.2 41.35,20.95 C16.2 43.85,20.95 44.65,20.14 L3.1
N120412: length 4.8
  TOP w0.5: L3.2 45.24,15.2 C17.1
N121910: length 8.9
  TOP w0.5: Q1.2 58.75,7.4 C20.2 59.2,7.25 59.95,6.5 59.95,4.1 59.4,3.55 R15.2 C21.2
N123723: length 10.2
  TOP w0.5: C17.2 50.55,12.85 Q2.3 R16.2
N124926: length 41.6
  TOP w0.5: C22.2 Q2.1 56.25,18.09 57.7,16.64 57.7,15.89 58.75,14.85 R16.1 60.85,12.79 60.85,2.9 59.9,1.95 R15.1 C21.1 56.68,2 R13.1 54.68,1.65 C19.2 43.88,1.72 XTAL1.3
N129422: length 11.7
  TOP w0.5: Q2.2 51.65,19.34 50.13,20.87 L4.3 51.53,24.5 C22.1
N221560: length 2.8
  TOP w0.5: C18.2 50.57,4.01 XTAL1.4
N828385: length 12.9
  TOP w0.2: U22.19 112.09,44.29 113.05,45.24 113.05,51.71 R31.1
N829333: length 2.3
  TOP w0.5: U31.G7 v1(112.26,56.01)
  BOTTOM w0.5: v1(112.26,56.01) 111.01,56.01 R43.1
N829669: length 2.1
  TOP w0.5: U31.K7 v1(112.2,52.2)
  BOTTOM w0.5: v1(112.2,52.2) 111.15,52.2 R44.1
N829685: length 1.3
  TOP w0.5: U31.H5 U31.G5
N830942: length 2.1
  TOP w0.2: R29.2 122.25,37.6 D3.A
N831005: length 2.1
  TOP w0.2: 120.97,40.4 122.5,40.4 D3.C
N831029: length 2
  TOP w0.2: U29.G7 92.47,55.99 v1(93.1,55.99)
  BOTTOM w0.2: R39.1 92.85,56.24 v1(93.1,55.99)
N831181: length 1.6
  TOP w0.2: U29.K7 v1(93.1,52.2)
  BOTTOM w0.2: v1(93.1,52.2) 92.25,52.2 R40.1
N831646: length 2.1
  TOP w0.2: 122.87,44.36 122.25,43.73 R28.2
N831650: length 2.1
  TOP w0.2: D2.C 122.5,46.53 120.97,46.53
N831853: length 2.2
  TOP w0.2: U30.G7 102.74,56.01 v1(102.75,55.99)
  BOTTOM w0.2: v1(102.75,55.99) 102.74,56.01 101.54,56.01 R41.1
N831855: length 2.1
  TOP w0.2: R27.2 122.25,49.86 D1.A
N831859: length 2.1
  TOP w0.2: 120.97,52.66 122.5,52.66 D1.C
N832005: length 2.2
  TOP w0.2: U30.K7 101.91,52.15 102.7,52.15 v1(102.75,52.2)
  BOTTOM w0.2: v1(102.75,52.2) 102.7,52.15 R42.1
N832074: length 2.1
  TOP w0.2: 122.87,32.1 122.25,31.47 R30.2
N832078: length 2.1
  TOP w0.2: D4.C 122.5,34.27 120.97,34.27
N852308: length 9.3
  TOP w0.2: U22.17 112,41.75 114.05,43.8 114.05,46.58 R32.1
N852494: length 6.2
  TOP w0.2: R33.1 112.81,39.21 U22.15
N852683: length 5.9
  TOP w0.2: R34.1 113.47,36.67 U22.13
N884986: length 5.1
  TOP w0.5: J3.1 C70.2
N885188: length 10.3
  TOP w0.2: L2.2 111.38,19.12 115.03,19.12 115.06,19.09 116.4,19.09 117.62,20.32 J2.1
N885276: length 10.3
  TOP w0.2: J1.1 117.6,4.84 116.4,3.65 115.03,3.65 C1.1 111.38,3.64 L1.2
N885442: length 5.1
  TOP w0.2: U34.6 108.78,7.95 L1.1
N1358395: length 1.8
  BOTTOM w0.2: R2003.1 118.5,67.25 J5.6
N1358407: length 1.7
  BOTTOM w0.2: J5.8 119.1,62.9 R2004.1
N1358411: length 1.6
  BOTTOM w0.2: R2005.1 119.45,61.25 J5.9
N1358515: length 3.2
  BOTTOM w0.2: R2000.1 118.2,64.25 J5.2
N1358527: length 3.1
  BOTTOM w0.2: R2001.1 117.94,66.25 J5.3
N1358539: length 1.7
  BOTTOM w0.2: J5.5 118.15,69.25 R2002.1
N1406173: length 10.8
  TOP w0.2: Y1.3 59.4,29.63 v1(59.4,31.34) 59.95,31.34 60.4,31.8 60.42,31.82 60.42,35.52 60.95,36.05 62.92,36.05 U50.9
  BOTTOM w0.2: R2009.1 v1(59.4,31.34)
N1406200: length 10.2
  TOP w0.2: U50.8 60.82,36.77 59.9,35.84 58.4,35.84 57.9,35.34 v1(57.9,34) 56.96,34 56.59,34.37
  BOTTOM w0.2: R2009.2 57.9,33 v1(57.9,34)
N1406547: length 5.9
  TOP w0.3: U50.4 65.65,36.77 v1(65.65,37.7) 65.16,37.2 U50.5
  BOTTOM w0.3: C2008.1 65.4,37.95 v1(65.65,37.7) 65.65,36.93 C2009.1 65.88,35.25 R2006.2
N1406997: length 14.6
  TOP w0.2: U50.10 61.2,35.54 60.85,35.2 60.85,31.34 61.65,30.55 64.2,30.55 64.66,31
  TOP w0.3: U50.19 64.66,31 64.96,30.7 v1(65.4,30.7) 65.66,30.95 U50.21
  BOTTOM w0.3: v1(65.4,30.7) 65.66,30.95 65.66,31.4 R2007.1
N1421557: length 5.1
  TOP w0.2: L2.1 108.78,23.43 U37.6
N1432081: length 29.5
  TOP w0.102: U2.M12 v2(63.25,43.9)
  TOP w0.2: U11.8 80.62,53.34 v1(81.9,53.34)
  BOTTOM w0.102: 67.94,43.06 67.34,43.06 66.5,43.9 v2(63.25,43.9)
  BOTTOM w0.2: v1(81.9,53.34) 80.75,52.2 80.75,45.06 78.75,43.06 67.94,43.06
N1432096: length 27.8
  TOP w0.1: U2.R11 62.1,41.75 67.94,41.75
  TOP w0.2: U11.3 79.72,50.07 79.5,49.84 79.5,47.76 80.75,46.51 80.75,43.66 79.78,42.7 69.05,42.7 68.1,41.75 67.94,41.75
N1432111: length 31.4
  TOP w0.1: U2.P10 61.21,41.93 67.69,41.93 67.94,42.19
  TOP w0.2: 67.94,42.19 68.85,43.09 79.62,43.09 80.35,43.83 80.35,46.34 79.1,47.59 79.1,52.45 79.4,52.74 80.53,52.74 U11.7
N1432121: length 35.8
  TOP w0.1: U2.T10 61.65,39.49 67.94,39.49
  TOP w0.2: 67.94,39.49 69.08,39.49 71.88,42.3 79.95,42.3 80.95,43.29 80.95,43.29 81.15,43.49 81.15,47.14 82.56,48.54 82.56,54.04 82,54.59 80.62,54.59 U11.10
N1438447: length 4.2
  TOP w0.2: SW2.2 63.7,25.89 63.7,27.2 65.06,28.56 U49.3
N1472359: length 4.6
  TOP w0.2: v1(70.99,36.29) 70.99,35.72 U51.1
  BOTTOM w0.2: R2010.2 R2011.1 72.51,35.55 C2010.1 v1(70.99,36.29)
N2993541: length 2.5
  TOP w0.5: C43.1 86.36,84.36 R25.2

## Copper pours and planes (outline as drawn)
0V9 on POWER: 36,61.9 43.55,61.9 46,59.45 46,28.5 48.75,28.5 49.15,28.89 49.15,31.25 49.35,31.45 63.4,31.45 66.05,28.8 68.3,28.8 69.3,29.8 69.3,34.75 69.45,34.89 71.35,34.89 72.3,33.95 72.3,26.14 71.55,25.39 32.2,25.39 29.2,28.39 29.2,61.3 29.85,61.95 35.95,61.95
1V2 on TOP: 89.15,59.31 89.15,69.79 89,69.94 84.35,69.94 84.2,69.79 84.2,59.18 89.03,59.18
1V2 on POWER: 36.25,69.5 36.25,86.34 47.75,86.34 56.3,77.79 56.3,76.84 63.85,69.29 89.25,69.29 89.25,66.25 80.55,57.55 72.95,57.55 72.95,51.45 72.5,50.99 64.55,50.99 63.65,50.09 63.65,32 60.3,28.64 46.25,28.64 46.25,59.49
1V8 on INNER2: 29.95,37.84 29.95,63.7 74.65,63.7 74.65,28.55 39.8,28.55 39.4,28.95 39.3,28.95 39.3,30.8 39.4,30.89 39.4,31.14 36.85,33.7 36.85,36.3 35.75,37.4 30.4,37.4 ; 14 cut-outs
2V5 on TOP: 98.55,59.31 98.55,69.85 98.43,69.98 93.73,69.98 93.6,69.85 93.6,59.31 93.73,59.18 98.43,59.18
2V5 on BOTTOM: 29.6,26 28.25,27.34 28.25,87.4 98.6,87.4 98.6,61.84 83.5,61.84 83.35,61.7 81.2,63.84 81.2,64.25 68.9,64.25 65.45,60.8 65.45,56.74 72,56.74 72.7,57.45 84.7,57.45 84.7,54.59 85.15,54.15 85.15,47.84 80.67,43.37 67.07,43.37 67.05,43.34 63.85,43.34 63.2,43.99 61.5,43.99 60.65,43.15 60.65,38.95 58.4,36.7 54.45,36.7 52.55,34.8 50.95,34.8 47.8,31.55 38.75,31.55 37.55,30.34 37.55,26.89 36.65,26 ; 16 cut-outs
3V3 on TOP: 107.95,59.31 107.95,69.85 107.82,69.98 103.12,69.98 103,69.85 103,59.31 103.12,59.18 107.82,59.18
3V3 on INNER2: 37.85,74.15 30.5,74.15 29.3,75.34 29.3,90.94 86.35,90.94 108.15,69.15 108.15,55.15 107.05,54.05 85.2,54.05 84.2,53.05 84.2,22.95 83.55,22.3 36.8,22.3 35.85,23.25 35.85,31 36.3,31.45 39.05,31.45 39.35,31.14 39.35,28.75 39.85,28.25 67.85,28.25 74.95,35.34 74.95,44.95 74.25,45.65 65.5,45.65 65.15,45.3 63.1,45.3 62.45,45.95 62.45,49.65 63.2,50.4 64.7,50.4 65.15,49.95 70.55,49.95 71,50.4 71,52.09 70,53.09 69.9,53.09 69.9,55.45 70.35,55.9 71.05,55.9 71.05,61.65 74.95,61.65 74.95,64.09 74.8,64.25 53,64.25 52.9,64.15 49.45,67.59 49.45,67.65 49.4,67.69 41.25,67.69 39.65,69.29 39.65,71.94 39.85,72.15
GND EARTH on TOP (solid shape): 124.87,24.04 124.87,16.51 117.25,16.51 117.25,19.05 119.64,19.05 122.97,20.32 119.64,21.59 117.63,21.59 116.26,20.23 114.23,20.23 114.23,24.04 114.48,24.29 124.62,24.29
GND EARTH on TOP (solid shape): 124.87,8.56 124.87,1.04 117.25,1.04 117.25,3.58 119.64,3.58 122.97,4.85 119.64,6.12 117.63,6.12 116.26,4.75 114.23,4.75 114.23,8.56 114.48,8.81 124.62,8.81
GND EARTH on GND: 115.32,0.64 115.32,29.25 119.6,33.53 119.6,61.45 121.85,63.7 121.85,69.34 119.6,71.59 119.6,78.15 109.45,88.29 82.95,88.29 81,86.34 81,77.75 80.5,77.25 78.4,77.25 78,77.65 78,89.84 81.45,93.29 125.09,93.29 125.09,0.9 124.83,0.64
V12N on POWER: 104.72,24.77 107.15,22.34 111.95,22.34 112.55,21.75 112.55,1.25 111.95,0.65 22.5,0.65 22.25,0.9 22.25,5.75 0.9,5.75 0.65,6 0.65,36.05 13,36.05 39.4,9.64 99.05,9.64 101.25,11.85 101.25,24.2 101.82,24.77
VCC on POWER: 165.5,90.07 164.18,93.25 161,94.57 128.73,94.57 126.26,93.54 125.23,91.07 125.23,0.84 124.89,0.5 22.43,0.5 22.09,0.84 22.09,5.58 0.84,5.58 0.5,5.92 0.5,108.38 0.84,108.72 22.09,108.72 22.09,114.96 22.43,115.3 124.91,115.3 125.23,115.01 125.23,107.07 126.26,104.59 128.73,103.57 161,103.57 170.55,99.61 174.5,90.07 174.5,79.34 170.55,69.8 161,65.84 157.65,65.84 154.47,64.53 153.15,61.34 153.15,52.59 154.18,50.12 156.65,49.09 158.55,49.09 158.55,37.9 139.15,37.9 139.15,49.09 140.65,49.09 143.12,50.12 144.15,52.59 144.15,61.34 148.1,70.89 157.65,74.84 161,74.84 164.18,76.16 165.5,79.34 ; 1 cut-out
0 on TOP: 40.55,1.9 40.55,17.75 40.05,18.25 29.2,18.25 28.45,17.5 28.45,1.9 29.4,0.95 39.6,0.95
0 on TOP: 93.6,58.95 98.7,58.95 98.9,59.15 98.9,69.84 99,69.94 102.6,69.94 102.8,69.75 102.8,47.65 102.7,47.55 98.4,47.55 98.2,47.74 98.2,54.74 98,54.95 93.7,54.95 93.6,55.05
0 on TOP: 84.2,58.95 89.3,58.95 89.5,59.15 89.5,69.84 89.6,69.94 93.2,69.94 93.4,69.75 93.4,47.65 93.4,47.64 93.4,45.55 93.2,45.34 89.2,45.34 88.8,45.74 88.8,54.74 88.6,54.95 84.3,54.95 84.2,55.05
0 on TOP: 103,58.95 108.1,58.95 108.3,59.15 108.3,69.84 108.4,69.94 112,69.94 112.2,69.75 112.2,47.65 112.1,47.55 107.8,47.55 107.6,47.74 107.6,54.74 107.4,54.95 103.1,54.95 103,55.05
0 on GND: 165.5,90.07 164.18,93.25 161,94.57 128.73,94.57 126.26,93.54 125.23,91.07 125.23,0.84 124.89,0.5 22.43,0.5 22.09,0.84 22.09,5.58 0.84,5.58 0.5,5.92 0.5,108.38 0.84,108.72 22.09,108.72 22.09,114.96 22.43,115.3 124.91,115.3 125.23,115.01 125.23,107.07 126.26,104.59 128.73,103.57 161,103.57 170.55,99.61 174.5,90.07 174.5,79.34 170.55,69.8 161,65.84 157.65,65.84 154.47,64.53 153.15,61.34 153.15,52.59 154.18,50.12 156.65,49.09 158.55,49.09 158.55,37.9 139.15,37.9 139.15,49.09 140.65,49.09 143.12,50.12 144.15,52.59 144.15,61.34 148.1,70.89 157.65,74.84 161,74.84 164.18,76.16 165.5,79.34 ; 2 cut-outs
Net_4 on TOP (solid shape): 9.62,107.11 9.63,107.07 9.63,107 9.63,106.88 9.63,106.17 9.63,104.94 9.64,103.66 9.64,103.53 9.65,103.38 9.63,103.21 9.61,103.19 9.56,103.19 9.44,103.19 9.26,103.18 9.05,103.18 8.83,103.18 8.43,103.19 8.22,103.19 7.5,104.25 7.49,104.43 7.48,104.59 7.48,104.71 8.13,104.71 8.13,104.67 8.21,104.1 8.23,104.03 8.26,103.97 8.29,103.91 8.32,103.86 8.35,103.81 8.39,103.77 8.48,103.71 8.88,103.67 8.95,103.73 8.95,105.29 8.92,105.38 8.81,105.59 8.75,105.64 8.7,105.7 8.61,105.7 8.54,105.7 8.43,105.66 8.38,105.61 8.35,105.58 8.32,105.55 8.3,105.51 8.27,105.47 8.25,105.43 8.24,105.39 8.22,105.35 8.16,105 8.13,104.75 8.13,104.71 7.48,104.71 7.48,104.79 7.48,104.88 7.49,104.96 7.49,105.04 7.5,105.1 7.5,105.16 7.52,105.26 8.91,106.08 8.95,106.36 8.95,107.09 9.49,107.16
Net_5 on TOP (solid shape): 5.7,106.11 6,105.59 6.05,105.42 6.06,103.98 6.06,103.84 6.06,103.72 6.06,103.46 6.09,103.28 6.09,103.25 6.08,103.22 6.05,103.2 6,103.19 5.91,103.19 5.78,103.18 5.16,103.18 4.98,103.18 4.84,103.19 4.74,103.19 4.66,103.2 4.6,103.21 4.56,103.22 4.47,103.26 4.42,103.29 4.38,103.32 4.34,103.34 4.31,103.38 4.27,103.41 4.22,103.48 4.17,103.56 4.05,104.09 4.05,104.13 4.69,104.13 4.69,104.08 4.71,103.97 5.06,103.67 5.16,103.67 5.24,103.67 5.35,103.7 5.38,103.73 5.4,103.99 5.4,104.44 5.39,104.68 5.38,104.7 5.22,104.72 5.16,104.71 4.77,104.47 4.74,104.43 4.73,104.39 4.71,104.35 4.7,104.3 4.69,104.24 4.69,104.19 4.69,104.13 4.05,104.13 4.06,104.26 4.08,104.39 4.15,104.57 4.19,104.65 5.04,105.15 5.09,105.16 5.37,105.33 5.35,105.41 5.34,105.47 5.31,105.53 5.29,105.59 5.25,105.63 5.21,105.67 5.17,105.7 5.06,105.75 4.99,105.77 4.86,105.77 4.78,105.76 4.29,105.66 4.29,106.04 4.34,106.07
Net_6 on TOP (solid shape): 2.6,106.24 2.67,106.23 2.84,105.87 2.82,105.68 2.51,105.7 2.38,105.7 2.28,105.65 1.87,105.07 1.86,105.04 1.85,104.91 1.84,104.76 1.85,104.46 1.85,104.4 1.86,104.32 1.88,104.26 2.06,103.88 2.17,103.8 2.24,103.76 2.34,103.71 2.75,103.74 2.78,103.74 2.8,103.73 2.82,103.72 2.83,103.7 2.83,103.66 2.84,103.61 2.84,103.46 2.81,103.22 2.78,103.2 2.39,103.16 1.58,103.44 1.5,103.51 1.16,104.76 1.25,105.29 1.51,105.79 1.54,105.83 1.62,105.91 1.67,105.96 1.76,106.03 1.82,106.08 2.18,106.23 2.25,106.24
Net_7 on TOP (solid shape): outline of 83 points within 11.04,103.15 13.13,106.24
Net_8 on TOP (solid shape): 19.34,106.24 19.45,106.24 19.53,106.23 19.6,106.22 19.64,106.2 19.67,106.18 19.7,106.14 19.7,106.08 19.71,105.92 19.57,105.68 19.45,105.7 19.36,105.7 19.27,105.69 19.19,105.68 19.12,105.65 19.06,105.61 19.03,105.59 18.96,105.52 18.91,105.46 18.7,104.77 18.7,104.64 18.7,104.52 18.72,104.37 18.79,104.13 18.81,104.09 18.83,104.04 18.86,103.99 18.89,103.94 18.92,103.9 18.96,103.86 19.02,103.81 19.28,103.7 19.71,103.7 19.71,103.45 19.71,103.34 19.7,103.3 19.7,103.27 19.68,103.25 19.67,103.23 19.63,103.21 19.58,103.19 19.52,103.18 19.45,103.17 19.37,103.16 19.29,103.16 19.21,103.16 19.13,103.16 18.97,103.17 18.57,103.33 18.38,103.51 18.17,103.85 18.05,104.4 18.04,104.54 18.04,104.68 18.04,104.81 18.33,105.73 18.39,105.81 18.43,105.85 18.51,105.94 18.64,106.05 18.74,106.12 19.25,106.24
Net_9 on TOP (solid shape): 22.16,106.24 22.24,106.23 22.96,105.06 22.97,104.88 22.96,104.68 22.77,104.53 22.58,104.52 22.23,104.52 21.58,104.52 21.66,103.93 21.69,103.9 21.72,103.86 21.75,103.83 21.78,103.8 21.83,103.77 21.87,103.75 21.97,103.7 22.68,103.73 22.72,103.73 22.75,103.73 22.77,103.71 22.78,103.68 22.78,103.64 22.6,103.22 22.54,103.2 22.49,103.19 22.42,103.18 22.34,103.17 22.18,103.16 22.02,103.16 21.9,103.16 21.65,103.21 21.45,103.3 21.38,103.35 21.26,103.47 21.18,103.56 21.04,103.77 20.92,104.18 20.87,104.71 20.88,104.77 20.92,105.09 21.55,105.09 21.57,105.01 21.59,104.99 21.62,104.99 21.78,104.99 21.99,104.99 22.19,104.99 22.29,105 22.34,105.24 22.08,105.72 22.05,105.74 22.03,105.75 22,105.75 21.97,105.75 21.93,105.75 21.9,105.74 21.66,105.54 21.61,105.42 21.58,105.33 21.57,105.29 21.56,105.21 21.55,105.09 20.92,105.09 21.13,105.73 21.38,106.03 21.44,106.07 22.04,106.24
Net_10 on TOP (solid shape): 16.02,106.23 16.51,105.82 16.61,105.49 16.62,105.44 16.62,105.38 16.63,105.3 16.63,105.19 16.63,105.05 16.64,104.88 16.64,104.67 16.64,104.13 16.64,103.88 16.64,103.67 16.64,103.52 16.63,103.32 16.63,103.23 16.62,103.2 16.46,103.18 16.09,103.19 16.05,103.19 16.02,103.2 16,103.21 15.98,103.22 15.97,103.25 15.97,103.51 15.97,103.63 15.97,103.77 15.97,103.92 15.97,104.26 15.97,105.24 15.58,105.69 15.25,105.69 15.22,105.63 15.21,105.59 15.21,105.42 15.21,105.06 15.21,103.23 14.58,103.22 14.57,103.33 14.57,103.44 14.56,103.59 14.56,103.81 14.56,104.47 14.56,104.91 14.55,105.13 14.64,106.23 14.76,106.23 15.31,106.23
V+12 on TOP: 103,54.74 107.3,54.74 107.4,54.65 107.4,47.74 107.2,47.55 103.1,47.55 103,47.65
V+12 on TOP: 93.6,54.74 97.9,54.74 98,54.65 98,47.74 97.8,47.55 93.7,47.55 93.6,47.65
V+12 on TOP: 84.2,54.74 88.5,54.74 88.6,54.65 88.6,45.74 88.2,45.34 84.5,45.34 84.2,45.65
V+12 on INNER2: 36.45,22 83.8,22 84.5,22.7 84.5,53.3 85,53.8 110.65,53.8 114,50.45 114,8.1 111.45,5.54 29.5,5.54 27.7,7.35 1.05,7.35 0.65,7.75 0.65,30.95 1.05,31.34 27.1,31.34

Small or netless copper shapes (teardrops, artwork): 2 on TOP
