# Allegro board fillets.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDS_OUT: length 41.7
  TOP w0.2: U4.20 v1(82.3,61.65)
  TOP w0.5: v1(103.6,74.75) 103.6,75.93 L5.1 106.33,75.96 C34.2 108.2,76.31 C36.2
  BOTTOM w0.5: v1(103.6,74.75) 103.6,63.24 102,61.65 v1(82.3,61.65)
DEN/: length 66.5
  TOP w0.2: 26.79,57.8 28.22,57.8 28.68,57.34 28.68,37.12 27.37,35.81 U7.17 ; 26.79,57.8 v1(26.75,57.84) ; 26.79,57.8 25.54,57.8 U9.48 ; v1(26.85,91.59) 25.65,91.59 U6.48
  BOTTOM w0.2: v1(26.85,91.59) 22.32,87.06 22.32,72.09 22.67,71.74 24.41,71.74 25.1,71.05 25.1,64.41 26.75,62.76 v1(26.75,57.84)
DHEN/: length 33.1
  TOP w0.2: v1(27.15,64.39) 27.15,64.39 27.15,64.05 26.67,63.56 26.67,63.56 26.49,63.39 26.49,63.39 26.45,63.34 25.65,63.34 U8.25 ; 26.04,37.08 27.21,37.08 v1(27.45,36.84)
  INNER2 w0.2: v1(27.45,36.84) 29.6,38.99 29.6,61.94 v1(27.15,64.39)
DI: length 63.2
  TOP w0.102: U1.C12 v2(42.9,72.94)
  INNER1 w0.102: v2(42.9,72.94) 42.95,72.9 42.95,70.49
  INNER1 w0.2: P1.7 42.68,34.56 41.85,35.39 30.15,35.39 29.5,36.05 29.5,59.93 34.32,64.75 42,64.75 42.95,65.7 42.95,70.49
DIFF1+: length 47.1
  TOP w0.102: U1.D16 v2(38.9,73.94)
  TOP w0.127: U8.20 19,65.34 19.12,65.46 19.71,65.46 23.65,69.4 23.65,72.53 v1(23.83,72.71) 23.55,72.99 23.55,73.12 23.55,73.12 23.55,73.95 22.6,74.9 22.6,84.2 21.1,85.71 21.1,87.94 19.57,89.48 19.12,89.48 19,89.6 U6.5
  INNER2 w0.102: 38.32,73.94 v2(38.9,73.94)
  INNER2 w0.127: 38.32,73.94 27.11,73.94 26.08,72.91 24.03,72.91 v1(23.83,72.71)
DIFF1-: length 50.2
  TOP w0.102: U1.D14 v2(40.9,73.94)
  TOP w0.127: U6.6 19,89.1 19.12,89.22 19.46,89.22 20.85,87.84 20.85,85.6 22.35,84.09 22.35,74.79 23.3,73.84 23.3,73.23 23.3,72.99 v1(23.02,72.71) 23.03,72.71 23.4,72.34 23.4,69.51 19.6,65.72 19.12,65.72 19,65.84 U8.19
  INNER2 w0.102: 38.32,74.33 39.06,74.33 39.28,74.1 39.28,73.66 39.45,73.5 40.45,73.5 v2(40.9,73.94)
  INNER2 w0.127: 38.32,74.33 38.19,74.2 27,74.2 25.97,73.17 24.18,73.17 24.07,73.28 23.59,73.28 23.48,73.17 23.47,73.17 v1(23.02,72.71)
DQ0: length 4.1
  TOP w0.2: 82.73,3.1 82.73,3.1 U38.12
DQ1: length 4.1
  TOP w0.2: U38.13 82.73,4.37 82.73,4.37
DQ2: length 4.1
  TOP w0.2: U38.14 78.6,5.64 82.73,5.64
DQ3: length 4.1
  TOP w0.2: U38.15 78.6,6.91 82.73,6.91
DQ4: length 4.1
  TOP w0.2: 82.73,8.18 82.73,8.18 U38.16
DQ5: length 4.1
  TOP w0.2: U38.17 78.6,9.45 82.73,9.45
DQ6: length 4.1
  TOP w0.2: 82.73,10.72 82.73,10.72 U38.18
DQ7: length 4.1
  TOP w0.2: U38.19 78.6,11.99 82.73,11.99
DQ8: length 4.1
  TOP w0.2: U39.12 82.73,18.58 82.73,18.58
DQ9: length 4.1
  TOP w0.2: 82.73,19.84 78.6,19.84 U39.13
DQ10: length 4.1
  TOP w0.2: 82.73,21.12 82.73,21.12 U39.14
DQ11: length 4.1
  TOP w0.2: 82.73,22.39 78.6,22.39 U39.15
DQ12: length 4.1
  TOP w0.2: U39.16 82.73,23.66 82.73,23.66
DQ13: length 4.1
  TOP w0.2: U39.17 78.6,24.93 82.73,24.93
DQ14: length 4.1
  TOP w0.2: 82.73,26.2 82.73,26.2 U39.18
DQ15: length 4.1
  TOP w0.2: U39.19 78.6,27.46 82.73,27.46
FPGA/: length 21.8
  TOP w0.2: U48.5 16.64,19.3 19.35,19.3 21.3,21.25 21.3,32.45 22.13,33.27 U7.15
GAIN: length 124
  TOP w0.102: U1.J4 v2(51.9,79.94)
  TOP w0.2: 95.45,27.16 95.49,27.2 v1(97.3,27.2) 97.9,27.8 97.9,31.84 v1(97.85,31.89) ; 95.45,11.68 97.04,11.68 v1(97.4,12.04)
  INNER1 w0.102: 55.59,79.69 55.42,79.69 55.27,79.54 52.3,79.54 v2(51.9,79.94)
  INNER1 w0.2: 55.59,79.69 59.32,79.69 60.42,78.59 62.73,78.59 62.78,78.54 63.62,78.54 63.66,78.59 69.59,78.59 71.3,76.88 71.3,76.32 75.37,72.25 97.37,72.25 101.81,67.81 101.81,58.49 100.9,57.58 100.9,47.66 102,46.56 103.25,45.31 103.25,36.44 103.85,35.84 103.85,33.55 102.1,31.8 97.95,31.8 v1(97.85,31.89) ; v1(97.3,27.2) 96.15,26.05 96.15,13 97.1,12.04 v1(97.4,12.04)
HS/: length 21.6
  TOP w0.2: U7.16 22.35,34.55 20.9,33.09 20.9,22.14 19.33,20.57 U48.4
JTAG_D0: length 43.7
  TOP w0.102: U2.E14 v2(65.25,51.9)
  BOTTOM w0.1: 61.87,39.24 60.85,40.26
  BOTTOM w0.102: 60.85,40.26 60.85,43.15 61,43.3 61.6,43.3 61.87,43.56 61.87,44.16 62.25,44.55 64.35,44.55 65.05,45.25 65.05,49.42 65.35,49.72 65.35,51.8 v2(65.25,51.9)
  BOTTOM w0.2: P1.8 43.97,31.59 48.15,31.59 49,32.45 49,33.59 49.58,34.17 57.22,34.17 57.65,34.6 59.91,34.6 60.85,35.55 61.87,35.55 62.75,36.43 62.75,38.03 62.75,38.03 62.75,38.36 61.87,39.24
LED1: length 1.7
  TOP w0.2: Q4.1 117.65,53.61 117.64,53.59 R31.2
LED2: length 1.7
  TOP w0.2: Q5.1 117.65,47.48 117.64,47.46 R32.2
LED3: length 1.7
  TOP w0.2: R33.2 117.64,41.33 117.65,41.35 Q6.1
LED4: length 1.7
  TOP w0.2: R34.2 117.64,35.2 117.65,35.22 Q7.1
LPF_OUT: length 4.7
  TOP w0.5: R18.2 91.97,76.66 C42.1 94.47,76.66 R17.2
MEMORY.CTRL.RCS0: length 85.5
  TOP w0.102: U1.J1 v2(53.9,79.94)
  TOP w0.2: U40.22 38.21,100.97 v1(36.22,100.97) ; U44.22 v1(80.25,100.97)
  INNER2 w0.2: v1(80.25,100.97) 75.07,100.97 72.8,98.69 58.4,98.69 56.75,100.34 50,100.34 49.38,100.97 v1(36.22,100.97)
  BOTTOM w0.1: 50.65,87.76 50.65,85.23 50.52,85.1 50.52,83.79 50.74,83.56 51.77,83.56 52.72,82.62 52.72,81.67 52.83,81.56 52.83,81.56 53.9,80.5 v2(53.9,79.94)
  BOTTOM w0.2: v1(36.22,100.97) 36.25,100.94 42.1,100.94 42.85,100.19 J7.26 42.85,91.54 43.75,90.65 48.5,90.65 50.65,88.5 50.65,87.76
MEMORY.CTRL.RCS1: length 82.4
  TOP w0.102: U1.G3 v2(52.9,76.94)
  TOP w0.2: U45.22 v1(91.05,100.97) ; U41.22 50.72,100.97 v1(50.75,101)
  INNER2 w0.2: v1(50.75,101) 50.95,100.79 56.87,100.79 57.92,99.75 v1(62.1,99.75) 63,99.75 65.47,102.21 69.53,102.21 70.2,101.54 74.35,101.54 74.65,101.84 79.45,101.84 79.65,102.04 80.8,102.04 81.4,102.65 88.1,102.65 88.25,102.79 89.22,102.79 v1(91.05,100.97)
  BOTTOM w0.1: 51.3,87.76 51.3,87 51,86.69 51,85.5 51.3,85.19 51.3,84.29 52.9,82.69 52.9,81.75 52.92,81.75 54.2,80.47 54.3,80.37 54.3,79.34 52.9,77.94 v2(52.9,76.94)
  BOTTOM w0.2: v1(62.1,99.75) 62.07,99.78 61.78,99.78 61.45,99.44 J7.76 61.45,96.79 61.7,96.54 62,96.54 62.35,96.19 62.35,94.79 61.7,94.15 61.7,93.09 59.95,91.34 52.4,91.34 51.3,90.25 51.3,87.76
MEMORY.CTRL.RCS2: length 108.6
  TOP w0.102: U1.F2 v2(53.9,75.94)
  TOP w0.2: U46.22 v1(101.97,100.97) ; v1(58.2,100.94) 60.02,100.94 U42.22
  INNER2 w0.2: v1(58.2,100.94) 62,100.94 63.7,102.65 68.25,102.65 68.6,103 68.6,103.89 69,104.29 69.6,104.29 69.95,103.94 69.95,102.5 70.5,101.94 74.1,101.94 74.6,102.44 v1(77.65,102.44) 80.6,102.44 82.3,104.15 87.6,104.15 88.55,103.19 89.7,103.19 91.93,100.97 v1(101.97,100.97)
  BOTTOM w0.1: v2(53.9,75.94) 53.9,76 53.28,76.62 53.28,78.03 54.5,79.25 54.5,80.43 53.08,81.85 53.08,82.81 51.5,84.4 51.5,85.29 51.2,85.59 51.2,86.59 51.7,87.09 51.7,87.76
  BOTTOM w0.2: v1(77.65,102.44) 77.65,99.5 77.4,99.25 76.65,99.25 76.45,99.04 J7.126 76.45,96.85 76.73,96.57 77.24,96.57 77.5,96.31 77.5,93.85 73.95,90.29 70.35,90.29 69.75,90.9 52.6,90.9 51.7,90 51.7,87.76
MEMORY.CTRL.RCS3: length 124.5
  TOP w0.102: U1.G6 v2(49.9,76.94)
  TOP w0.2: U43.22 70.94,100.94 v1(69.1,100.94) ; U47.22 v1(112.77,100.97)
  INNER2 w0.2: v1(112.77,100.97) 102.82,100.97 102.57,100.72 102.57,100.71 102.22,100.36 102.22,100.36 102.2,100.34 90.8,100.34 89.03,102.12 v1(88.47,102.12) 87.5,101.15 82.3,101.15 81.85,101.59 79.9,101.59 79.75,101.44 74.85,101.44 74.35,100.94 v1(69.1,100.94)
  BOTTOM w0.1: v2(49.9,76.94) 50.35,76.5 52.7,76.5 53.65,75.54 54.2,75.54 54.3,75.65 54.3,76.19 54.1,76.4 53.8,76.4 53.5,76.69 53.5,77.94 54.7,79.15 54.7,80.5 53.26,81.94 53.26,82.89 51.68,84.47 51.68,85.37 51.4,85.65 51.4,86.5 52.1,87.19 52.1,87.76
  BOTTOM w0.2: 52.1,87.76 52.1,89.69 52.8,90.4 69.69,90.4 70.23,89.84 89.9,89.84 91.45,91.4 J7.176 91.45,99.75 90.83,100.37 90.8,100.37 89.05,102.12 v1(88.47,102.12)
MEMORY.CTRL.RWE: length 129.7
  TOP w0.102: U1.M11 v2(43.9,82.94)
  TOP w0.2: U47.29 111.39,109.85 110.77,110.48 105.91,110.48 105.28,109.85 U46.29 100.74,109.85 100.12,110.48 94.59,110.48 93.94,109.84 92.8,109.84 U45.29 92.77,109.84 v1(91.05,109.84) 90.6,109.4 89.25,109.4 88.16,110.48 84.13,110.48 83.49,109.84 81.89,109.84 U44.29 81.86,109.84 80.35,109.84 80.15,110.04 v1(77.45,110.04) 77,110.04 76.56,110.48 73.22,110.48 72.57,109.84 70.97,109.84 U43.29 69.84,109.85 69.2,110.5 62.32,110.5 v1(61.66,109.84) 60.06,109.84 U42.29 59.8,110.09 58.53,110.09 58.48,110.15 56.15,110.15 55.6,110.69 54.35,110.69 54.13,110.48 51.39,110.48 50.74,109.84 49.15,109.84 U41.29 46.19,109.85 v1(46.15,109.9) 45.35,110.69 43.38,110.69 43.19,110.5 40.35,110.5 39.69,109.84 38.23,109.84 U40.29
  INNER1 w0.102: 45.68,87.76 45.46,87.54 45.46,84.97 45.06,84.56 44.74,84.56 44.28,84.1 44.28,83.79 43.9,83.41 v2(43.9,82.94)
  INNER1 w0.2: v1(46.15,109.9) 45.15,108.9 45.15,103.29 47.2,101.25 47.2,93.25 45.68,91.73 45.68,87.76
  BOTTOM w0.2: J7.127 76.75,109.34 v1(77.45,110.04) ; v1(61.66,109.84) 61.75,109.74 J7.77 ; J7.27 43.15,109.09 43.95,109.9 v1(46.15,109.9) ; v1(91.05,109.84) 91.75,109.15 J7.177
MEMORY.RA0: length 131.2
  TOP w0.102: U1.P5 v2(50.9,84.94)
  TOP w0.15: 61.98,99.07 62.18,99.07 62.95,99.69
  TOP w0.2: U47.12 105.99,99.69 105.36,99.07 100.07,99.07 98.9,100.25 98.4,100.25 97.85,99.69 U46.12 95.4,99.69 94.78,99.07 90.88,99.07 89.3,100.65 87.75,100.65 86.8,99.69 U45.12 84.16,99.69 83.53,99.07 79.42,99.07 v1(78.8,99.69) 78.05,99.69 77.3,100.44 76.8,100.44 76.05,99.69 U44.12 73.24,99.69 72.62,99.07 68.53,99.07 v1(67.1,100.5) 65.95,100.5 65.15,99.69 U43.12 62.95,99.69 ; 61.98,99.07 57.97,99.07 56.95,100.09 55.45,100.09 v1(55.05,99.69) U42.12 51.57,99.69 50.94,99.07 45.5,99.07 44.88,99.69 U41.12 40.2,99.69 39.58,99.07 34.59,99.07 34,99.66 v1(34,99.69) U40.12
  INNER1 w0.102: 52.11,87.76 52.11,87.21 50.9,86 v2(50.9,84.94)
  INNER1 w0.2: 52.11,87.76 52.11,90.31 53,91.19 53,97.65 v1(55.05,99.69)
  BOTTOM w0.2: J7.101 68.95,104.91 67.1,103.06 v1(67.1,100.5) ; J7.151 83.95,105.04 82.7,103.79 82.7,100.79 81.6,99.69 v1(78.8,99.69) ; v1(34,99.69) 34.45,100.15 34.45,104.4 34.05,104.79 34.05,105.67 34.48,106.09 J7.1 ; v1(55.05,99.69) 55.05,101.59 53.95,102.69 J7.51
MEMORY.RA1: length 118.3
  TOP w0.102: U1.P10 v2(44.9,84.94)
  TOP w0.2: U40.11 32.38,100.97 v1(32.85,100.5) 35.85,100.5 36.01,100.34 39.37,100.34 39.88,100.84 39.9,100.84 40.02,100.97 U41.11 44.91,100.97 45.53,100.34 v1(46.5,100.34) 48.01,100.34 48.01,100.34 50.29,100.34 50.29,100.34 51,100.34 51.62,100.97 U42.11 57.33,100.97 57.95,100.34 61.25,100.34 61.87,100.97 U43.11 64.97,100.97 65.7,101.69 67.5,101.69 69.05,100.15 v1(69.25,100.15) 69.44,100.34 72.62,100.34 73.24,100.97 U44.11 75.97,100.97 76.4,101.4 78.7,101.4 79.76,100.34 83.3,100.34 v1(83.5,100.54) 83.92,100.97 U45.11 86.67,100.97 87.15,101.44 89.7,101.44 90.81,100.34 94.25,100.34 94.87,100.97 U46.11 97.99,100.97 98.07,101.04 99.55,101.04 100.26,100.34 105.36,100.34 105.99,100.97 U47.11
  INNER1 w0.102: v2(44.9,84.94) 44.9,85.41 45.28,85.79 45.28,87.76
  INNER1 w0.2: 45.28,87.76 45.28,91.93 46.5,93.15 v1(46.5,100.34)
  BOTTOM w0.2: J7.52 54.25,99.04 53.9,99.4 53.9,100.04 53.6,100.34 v1(46.5,100.34) ; v1(83.5,100.54) 84.25,99.79 J7.152 ; J7.2 35.16,97.9 35.09,97.82 33.87,97.82 32.85,98.84 v1(32.85,100.5) ; J7.102 v1(69.25,100.15)
MEMORY.RA2: length 119.8
  TOP w0.102: U1.N11 v2(43.9,83.94)
  TOP w0.2: U47.10 106.74,102.24 106.12,101.61 101.76,101.61 101.25,101.09 100.07,101.09 99.72,101.44 99.7,101.44 98.91,102.24 U46.10 95.34,102.24 94.71,101.61 90.78,101.61 89.6,102.79 88.1,102.79 87.54,102.24 U45.10 84.04,102.24 v1(83.75,101.94) 83.39,101.59 80.65,101.59 80.42,101.82 76.47,101.82 76.06,102.24 U44.10 73.89,102.24 73.27,101.61 v1(68.65,101.61) 68.03,102.24 U43.10 63.04,102.24 62.41,101.61 55.94,101.61 v1(55.65,101.9) 55.31,102.24 U42.10 51.47,102.24 50.85,101.61 45.08,101.61 v1(44.45,102.25) 44.44,102.24 U41.10 40.14,102.24 39.52,101.61 v1(35.62,101.61) 34.38,102.84 33.15,102.84 32.54,102.24 U40.10
  INNER1 w0.102: v2(43.9,83.94) 43.9,84.41 44.46,84.97 44.46,87.76
  INNER1 w0.2: v1(44.45,102.25) 44.45,95.34 44.76,95.03 44.76,94.2 44.45,93.89 44.45,87.77 44.46,87.76
  BOTTOM w0.2: v1(55.65,101.9) 54.55,103 J7.53 ; J7.103 69.55,104.94 68.65,104.04 v1(68.65,101.61) ; J7.153 84.55,103.44 83.75,102.65 v1(83.75,101.94) ; J7.3 35.95,105.05 35.3,104.4 35.3,101.93 v1(35.62,101.61)
MEMORY.RA3: length 132.7
  TOP w0.102: U1.R9 v2(45.9,85.94)
  TOP w0.2: 34.02,103.5 v1(33.35,103.5) 32.75,103.5 32.74,103.5 U40.9 ; 34.02,103.5 34,103.5 ; 34.02,103.5 34.85,103.5 35.47,102.88 39.38,102.88 40.01,103.5 40.14,103.5 40.15,103.5 40.65,103.5 40.66,103.5 U41.9 44.92,103.5 45.53,102.9 v1(47,102.9) 47.95,102.9 47.97,102.88 50.98,102.88 51.61,103.5 U42.9 55.83,103.5 56.46,102.88 62.09,102.88 62.71,103.5 U43.9 68.14,103.5 68.75,102.9 v1(69.3,102.9) 69.31,102.88 72.59,102.88 73.21,103.5 U44.9 74.83,103.44 79.2,103.44 79.77,102.88 83.19,102.88 83.6,103.29 v1(83.6,103.5) U45.9 86.36,103.5 86.85,104 87.75,104 88.15,103.59 90.05,103.59 90.76,102.88 94.78,102.88 95.41,103.5 U46.9 100.94,103.5 101.56,102.88 105.69,102.88 106.31,103.5 U47.9
  INNER1 w0.102: 46.48,87.76 46.48,86.99 45.9,86.41 v2(45.9,85.94)
  INNER1 w0.2: v1(47,102.9) 47,102.65 48,101.65 48,92.84 46.48,91.33 46.48,87.76
  BOTTOM w0.2: J7.104 69.85,102.34 v1(69.3,102.9) ; J7.154 84.85,100.84 84.45,101.25 83.4,101.25 83.1,101.54 83.1,103 v1(83.6,103.5) ; v1(47,102.9) 50.4,102.9 51.2,102.09 53.95,102.09 54.3,101.75 54.3,99.59 54.85,99.04 J7.54 ; v1(33.35,103.5) 32.75,102.9 32.75,101.59 33.45,100.9 33.45,100.25 33.35,100.15 33.35,99.4 33.65,99.09 34.55,99.09 34.67,99.22 35.96,99.22 36.14,99.04 36.14,99.04 36.25,98.93 J7.4
MEMORY.RA4: length 117
  TOP w0.102: U1.P8 v2(47.9,84.94)
  TOP w0.2: U40.8 33.98,104.78 34.61,104.15 v1(35.9,104.15) 39.41,104.15 40.03,104.78 U41.8 42.72,104.78 43.55,103.94 46.45,103.94 v1(46.65,104.15) 51.25,104.15 51.88,104.78 U42.8 54.42,104.78 54.8,104.4 v1(55.4,104.4) 55.7,104.69 57.9,104.69 58.44,104.15 62.16,104.15 62.78,104.78 U43.8 65.53,104.78 65.55,104.79 66.71,104.79 67.16,104.34 68.6,104.34 v1(69.25,103.69) 69.7,104.15 72.15,104.15 72.34,104.34 73.25,104.34 73.68,104.78 U44.8 76.52,104.78 77.15,104.15 83.53,104.15 84.16,104.78 U45.8 87.67,104.78 88.25,104.19 v1(88.8,104.19) 88.84,104.15 94.6,104.15 95.23,104.78 U46.8 98.57,104.78 99.2,104.15 105.36,104.15 105.99,104.78 U47.8
  INNER1 w0.102: 47.59,87.76 47.52,87.69 47.52,85.79 47.9,85.41 v2(47.9,84.94)
  INNER1 w0.2: v1(46.65,104.15) 46.85,103.94 47.4,103.94 48.8,102.55 48.8,88.97 47.59,87.76
  BOTTOM w0.2: J7.55 55.15,104.65 v1(55.4,104.4) ; v1(69.25,103.69) 70.15,104.59 J7.105 ; J7.5 36.55,104.8 v1(35.9,104.15) ; J7.155 85.15,103.75 86.35,102.54 87.8,102.54 88.8,103.54 v1(88.8,104.19)
MEMORY.RA5: length 164.1
  TOP w0.102: U1.R7 v2(48.9,85.94)
  TOP w0.2: U40.7 34.02,106.04 v1(34.65,105.42) 39.47,105.42 40.1,106.04 U41.7 44.88,106.04 45.53,105.4 47.6,105.4 v1(47.65,105.44) 47.7,105.4 50.29,105.4 50.29,105.4 50.85,105.4 51.5,106.04 U42.7 55.65,106.04 56.15,105.54 58.38,105.54 58.51,105.42 62.02,105.42 62.65,106.04 U43.7 66.71,106.04 67.33,105.42 73.03,105.42 73.65,106.04 U44.7 76.55,106.04 77.18,105.42 83.53,105.42 84.16,106.04 U45.7 88.3,106.04 88.92,105.42 94.43,105.42 95.05,106.04 U46.7 96.7,106.15 99.95,106.15 100.67,105.42 105.36,105.42 105.99,106.04 U47.7
  INNER1 w0.1: v2(48.9,85.94) 48.9,86.29 49.4,86.79 49.4,87.5 49.66,87.76
  INNER1 w0.2: v1(47.65,105.44) 48.7,105.44 50,104.15 50,100.09 50.95,99.15 v1(50.95,92.19) 50.05,91.29 50.05,90.8 50.25,90.6 50.25,88.34 49.66,87.76
  INNER2 w0.2: v1(55.45,92.19) 56.05,92.19 57.15,91.09 v1(70.4,91.09) 70.6,90.9 78.4,90.9 v1(78.65,91.15)
  BOTTOM w0.2: J7.6 36.85,100.17 36.65,100.37 35.98,100.37 34.86,101.49 34.86,104.63 34.65,104.84 v1(34.65,105.42) ; v1(70.4,91.09) 70.45,91.15 J7.106 ; J7.156 85.45,96.36 85,95.91 85,95.29 83.75,94.04 83.75,93.79 83.15,93.19 80.7,93.19 v1(78.65,91.15) ; v1(50.95,92.19) v1(55.45,92.19) J7.56
MEMORY.RA6: length 145.7
  TOP w0.102: U1.P6 v2(49.9,84.94)
  TOP w0.2: U40.6 v1(34,107.31) 34.62,106.69 39.55,106.69 40.17,107.31 U41.6 45.23,107.31 45.86,106.69 50.79,106.69 51.42,107.31 U42.6 54.57,107.31 v1(55,107.75) 55.95,107.75 57,106.69 62.09,106.69 62.72,107.31 U43.6 65.17,107.31 65.5,107.65 v1(67.85,107.65) 68.81,106.69 72.94,106.69 73.57,107.31 U44.6 76.53,107.31 77.15,106.69 79.84,106.69 79.85,106.69 80.7,106.69 80.71,106.69 83.53,106.69 84.16,107.31 U45.6 88.23,107.31 88.86,106.69 94.25,106.69 94.85,107.29 96.58,107.29 U46.6 100.08,107.31 100.7,106.69 v1(100.85,106.69) 100.85,106.69 105.36,106.69 105.99,107.31 U47.6
  INNER1 w0.1: v2(49.9,84.94) 49.9,85.04 50.35,85.5 50.35,86.59 51.05,87.29 51.05,87.76
  INNER1 w0.2: v1(100.85,106.69) 100.8,106.69 99.9,107.59 99.9,110.09 97.9,112.09 89.4,112.09 89,112.5 89,113.29 88.5,113.79 v1(87.95,113.79) ; 51.05,87.76 51.05,90.59 51.15,90.7 51.15,90.71 52,91.56 52,92.69 51.8,92.9 51.8,106.29 53.25,107.75 v1(55,107.75)
  BOTTOM w0.2: v1(67.85,107.65) 68.05,107.44 70.5,107.44 70.75,107.19 J7.107 ; v1(87.95,113.79) 86.5,113.79 85.75,113.04 J7.157 ; J7.57 55.75,107.34 55.35,107.75 v1(55,107.75) ; v1(34,107.31) 34.33,107.65 35.35,107.65 35.45,107.54 35.95,107.54 36.05,107.65 36.64,107.65 37.15,107.13 J7.7
MEMORY.RA7: length 183.5
  TOP w0.102: U1.N5 v2(50.9,83.94)
  TOP w0.2: U40.5 v1(32.91,108.59) 35.14,108.59 35.3,108.75 36.05,108.75 36.83,107.96 39.61,107.96 40.24,108.59 U41.5 42.12,108.5 45.4,108.5 45.94,107.96 50.79,107.96 51.42,108.59 U42.5 54.04,108.59 54.44,108.99 v1(54.76,108.99) 54.77,108.99 54.82,108.94 56.25,108.94 57.24,107.96 58.88,107.96 58.9,107.94 61.8,107.94 62.44,108.59 U43.5 63.91,108.65 68.95,108.65 69.63,107.96 73.02,107.96 73.64,108.59 U44.5 76.46,108.59 77.45,107.59 80.37,107.59 80.73,107.96 83.53,107.96 84.16,108.59 U45.5 88.21,108.59 88.84,107.96 93.97,107.96 94.6,108.59 94.85,108.59 94.86,108.59 U46.5 100.06,108.59 100.69,107.96 105.36,107.96 105.99,108.59 U47.5
  INNER1 w0.102: 51.55,87.2 50.65,86.3 50.65,85.39 50.45,85.19 50.45,84.4 v2(50.9,83.94)
  INNER1 w0.2: 51.55,87.2 51.55,90.54 52.4,91.39 v1(52.4,93.19) 52.4,93.25 52.6,93.44 52.6,105.69 52.8,105.9 55.3,105.9 56.3,106.9 56.3,108.59 55.91,108.99 v1(54.76,108.99)
  INNER2 w0.2: v1(52.4,93.19) 52.45,93.19 53.05,92.59 55,92.59 55.2,92.79 v1(56.05,92.79) 57.02,91.82 70.77,91.82 v1(71.1,91.5) 71.3,91.29 77.95,91.29 78.55,91.9 79.95,91.9 v1(80.15,91.69)
  BOTTOM w0.2: v1(71.1,91.5) 71.05,91.54 J7.108 ; v1(80.15,91.69) 81.25,92.79 83.35,92.79 83.75,93.19 84.6,93.19 84.95,93.55 84.95,94.59 85.4,95.04 85.4,95.74 86.05,96.39 J7.158 ; J7.58 56.05,96.65 55.85,96.44 55.85,93 v1(56.05,92.79) ; J7.8 37.45,96.85 37.09,96.5 35.95,96.5 35.85,96.4 31.7,96.4 30.75,97.34 30.75,106.43 v1(32.91,108.59)
MEMORY.RA8: length 126.2
  TOP w0.102: U1.L8 v2(47.9,81.94)
  TOP w0.2: U47.27 111.38,107.31 110.75,107.94 105.91,107.94 105.53,107.56 105.51,107.56 105.27,107.31 U46.27 100.68,107.31 100.06,107.94 94.64,107.94 93.99,107.29 92.8,107.29 U45.27 88.83,107.31 88.2,107.94 v1(87.35,107.94) 84.14,107.94 83.49,107.29 81.89,107.29 U44.27 80.75,107.31 80.63,107.19 77.25,107.19 76.5,107.94 73.6,107.94 72.95,107.29 70.97,107.29 U43.27 69.43,107.31 v1(68.7,108.04) 68.5,108.25 65.4,108.25 65.1,107.94 62.7,107.94 62.05,107.29 60.06,107.29 U42.27 57.28,107.31 56.25,108.34 v1(55.7,108.34) 54.6,108.34 54.2,107.94 51.39,107.94 50.74,107.29 49.15,107.29 U41.27 47.48,107.31 v1(47.45,107.34) 45.85,107.34 45.25,107.94 40.2,107.94 39.55,107.29 38.23,107.29 U40.27 36.83,107.31 36,108.15 v1(35.7,108.15)
  INNER1 w0.102: v2(47.9,81.94) 47.9,82.41 47.52,82.79 47.52,84.48 47.1,84.9 47.1,87.76
  INNER1 w0.2: 47.1,87.76 47.1,87.83 48.4,89.13 48.4,102.34 47.24,103.5 46.35,103.5 46.05,103.8 46.05,106.09 47.3,107.34 v1(47.45,107.34)
  BOTTOM w0.2: J7.159 86.35,107.59 86.7,107.94 v1(87.35,107.94) ; v1(35.7,108.15) 37.35,108.15 37.75,107.74 J7.9 ; J7.109 71.35,107.65 71.05,107.94 68.85,107.94 68.8,108 68.75,108 v1(68.7,108.04) ; J7.59 56.35,107.65 55.7,108.29 v1(55.7,108.34)
MEMORY.RA9: length 209.1
  TOP w0.102: U1.M6 v2(49.9,82.94)
  TOP w0.2: v1(38.95,91.9) 48.6,91.9 50.5,93.79 53,93.79 v1(53.6,93.19) ; U47.26 111.35,106.04 v1(110.73,106.67) 106.02,106.67 105.4,106.04 U46.26 100.65,106.04 100.03,106.67 94.79,106.67 94.15,106.03 92.8,106.03 U45.26 88.9,106.04 88.28,106.67 84.13,106.67 83.49,106.03 81.89,106.03 U44.26 77.2,106.04 76.56,106.69 73.55,106.69 72.88,106.03 70.97,106.03 U43.26 67.34,106.04 66.71,106.67 62.67,106.67 62.03,106.03 60.06,106.03 U42.26 56.7,106.04 56.05,106.69 54.1,106.69 54.1,106.69 51.39,106.69 50.73,106.03 49.15,106.03 U41.26 45.51,106.04 44.88,106.67 40.13,106.67 39.48,106.03 38.23,106.03 U40.26
  INNER1 w0.1: 52.76,87.76 52.76,87.41 51.5,86.15 51.5,83.9 50.55,82.94 v2(49.9,82.94)
  INNER1 w0.2: v1(110.25,93.29) 110.25,106.19 v1(110.73,106.67) ; v1(53.6,93.19) 53.6,91.15 52.76,90.31 52.76,87.76
  INNER2 w0.2: v1(53.6,93.19) 55.6,93.19 55.8,93.4 56.3,93.4 56.95,92.75 v1(57,92.75) 57.52,92.22 71.52,92.22 v1(71.65,92.09) 72.05,91.69 77.78,91.69 78.38,92.29 81.5,92.29 v1(81.6,92.19) 93.15,92.19 94.25,93.29 v1(110.25,93.29)
  BOTTOM w0.2: v1(81.6,92.19) 84.25,92.19 85.8,93.75 85.8,95.58 86.65,96.43 J7.160 ; J7.110 v1(71.65,92.09) ; v1(57,92.75) 56.25,93.5 56.25,96.25 56.65,96.65 J7.60 ; v1(38.95,91.9) 37.75,91.9 37.15,92.5 37.15,95.96 37.76,96.57 37.77,96.57 38.05,96.85 J7.10
MEMORY.RA10: length 115.3
  TOP w0.102: U1.T10 v2(44.9,86.94)
  TOP w0.2: v1(36.5,102.25) 38.2,102.25 U40.23 38.23,102.22 39.37,102.22 40.02,102.86 44.78,102.86 45.35,102.29 v1(45.35,102.25) 46.51,102.25 46.52,102.24 U41.23 49.15,102.22 50.89,102.22 51.53,102.86 55.8,102.86 56.41,102.24 v1(56.7,102.24) 60.03,102.25 U42.23 62.04,102.24 62.66,102.86 68.13,102.86 68.76,102.24 U43.23 72.79,102.24 v1(73.1,102.54) 73.41,102.86 76.38,102.86 76.57,103.04 78.9,103.04 79.71,102.24 U44.23 81.89,102.22 83.17,102.22 83.81,102.86 86.91,102.86 v1(87.42,103.37) 87.6,103.19 89.8,103.19 90.76,102.24 U45.23 92.8,102.22 94.72,102.22 95.37,102.86 100.84,102.86 101.45,102.25 103.69,102.25 U46.23 105.69,102.24 106.31,102.86 110.73,102.86 111.36,102.24 U47.23
  INNER1 w0.102: 44.88,87.76 44.9,87.74 v2(44.9,86.94)
  INNER1 w0.2: v1(45.35,102.25) 45.25,102.15 45.25,92.5 44.88,92.13 44.88,87.76
  BOTTOM w0.2: J7.161 86.95,103.84 v1(87.42,103.37) ; J7.11 38.35,104.09 v1(36.5,102.25) ; v1(73.1,102.54) 73.5,102.94 73.5,104.44 73.25,104.69 72.25,104.69 71.95,105 J7.111 ; v1(56.7,102.25) 56.4,102.54 56.4,104.34 56.95,104.89 J7.61
MEMORY.RA11: length 176.4
  TOP w0.102: U1.P11 v2(43.9,84.94)
  TOP w0.2: U47.25 111.32,104.78 110.69,105.4 105.91,105.4 105.28,104.78 U46.25 100.62,104.78 99.65,105.75 98.3,105.75 97.96,105.4 95.26,105.4 94.62,104.75 92.8,104.75 U45.25 91.03,104.78 91.03,104.77 88.97,104.77 88.34,105.4 84.13,105.4 83.49,104.75 81.89,104.75 U44.25 77.17,104.78 76.55,105.4 73.6,105.4 72.96,104.75 70.97,104.75 U43.25 67.34,104.78 66.71,105.4 62.66,105.4 62.01,104.75 60.06,104.75 U42.25 58.59,104.78 58.21,105.15 55.55,105.15 55.3,105.4 51.75,105.4 51.11,104.75 49.15,104.75 U41.25 46.48,104.78 46.45,104.75 46.4,104.75 46.2,104.54 v1(43.85,104.54) 43.85,105.15 43.59,105.4 40.06,105.4 39.41,104.75 38.23,104.75 U40.25 ; v1(38.55,92.69) 43.05,92.69 v1(43.7,93.34)
  INNER1 w0.102: 43.9,87.76 43.9,87.48 44.28,87.1 44.28,85.79 43.9,85.41 v2(43.9,84.94)
  INNER1 w0.2: v1(43.85,104.54) 43.85,101.49 42.93,100.57 42.93,100.07 43.85,99.15 43.85,95.37 44.36,94.86 44.36,94.37 43.85,93.86 43.85,93.5 v1(43.7,93.34) 43.9,93.15 43.9,87.76
  INNER2 w0.2: v1(43.7,93.34) 44.05,92.99 49.6,92.99 50.4,93.79 53.85,93.79 54.05,93.59 55.44,93.59 55.63,93.79 56.8,93.79 57.77,92.82 v1(57.82,92.82) 57.95,92.69 72.6,92.69 v1(72.85,92.94) 73.7,92.09 77.55,92.09 78.25,92.79 86.65,92.79 v1(86.8,92.94)
  BOTTOM w0.2: J7.12 38.65,96.85 37.55,95.75 37.55,93.09 37.95,92.69 v1(38.55,92.69) ; J7.62 57.25,96.65 56.65,96.04 56.65,94 v1(57.82,92.82) ; v1(72.85,92.94) 72.25,93.55 J7.112 ; J7.162 87.25,96.46 86.2,95.41 86.2,93.55 v1(86.8,92.94)
MEMORY.RA12: length 123.4
  TOP w0.102: U1.T9 v2(45.9,86.94)
  TOP w0.2: U47.4 105.99,109.85 105.36,109.23 100.71,109.23 100.09,109.85 U46.4 94.61,109.85 93.98,109.23 91.5,109.23 91.26,109 89,109 88.77,109.23 88.14,109.85 v1(87.55,109.85) U45.4 84.16,109.85 83.53,109.23 80.4,109.23 80.28,109.34 77,109.34 76.49,109.85 U44.4 73.24,109.85 v1(72.55,109.16) 72.48,109.23 69.77,109.23 68.9,110.09 65.35,110.09 65.11,109.85 U43.4 62.53,109.85 61.9,109.23 58.85,109.23 58.38,109.69 58.37,109.69 58.31,109.75 55.7,109.75 v1(55.39,110.05) 54.26,110.05 54.06,109.85 U42.4 51.42,109.85 50.79,109.23 46.81,109.23 v1(46.8,109.25) 45.95,109.25 44.95,110.25 43.5,110.25 43.11,109.85 U41.4 40.31,109.85 39.69,109.23 36.56,109.23 v1(36.55,109.25) 34.57,109.25 33.96,109.85 U40.4
  INNER1 w0.102: v2(45.9,86.94) 45.9,87.58 46.08,87.76
  INNER1 w0.2: v1(46.8,109.25) 45.65,108.09 45.65,103.4 47.6,101.44 47.6,93.04 46.08,91.53 46.08,87.76
  BOTTOM w0.2: J7.113 v1(72.55,109.16) ; J7.63 57.55,107.13 57.27,107.42 57.17,107.42 56.35,108.25 56.35,109.04 55.5,109.9 55.5,109.94 55.45,109.99 55.45,110 v1(55.39,110.05) ; v1(87.55,109.85) 87.55,108.59 87.95,108.19 87.95,107.69 87.55,107.29 J7.163 ; J7.13 38.95,108.9 38.65,109.19 36.6,109.19 v1(36.55,109.25)
MEMORY.RA13: length 178.1
  TOP w0.102: U1.T8 v2(47.9,86.94)
  TOP w0.2: U47.28 111.41,108.59 110.79,109.21 105.97,109.21 105.34,108.59 U46.28 100.71,108.59 100.09,109.21 94.61,109.21 93.96,108.56 92.8,108.56 U45.28 92.77,108.59 88.8,108.59 88.16,109.23 84.15,109.23 83.49,108.56 81.89,108.56 U44.28 80.64,108.59 80.05,108 77.65,108 76.44,109.21 73.52,109.21 72.85,108.54 71,108.54 U43.28 69.61,108.59 68.99,109.21 62.45,109.21 61.81,108.57 61.37,108.56 60.06,108.56 U42.28 58.91,108.59 58.15,109.34 55.27,109.34 55.12,109.5 55.1,109.5 54.95,109.65 54.52,109.65 54.1,109.23 51.41,109.23 50.74,108.56 49.15,108.56 U41.28 47.36,108.59 v1(47.35,108.59) 45.95,108.59 44.85,109.69 43.65,109.69 43.19,109.23 40.28,109.23 39.62,108.56 38.23,108.56 U40.28
  INNER1 w0.102: 48.16,87.76 47.9,87.5 v2(47.9,86.94)
  INNER1 w0.2: v1(47.35,108.59) 47.78,108.17 47.78,108.12 48.05,107.84 48.05,106.8 47.75,106.5 47.1,106.5 46.6,106 46.6,105.04 47.3,104.34 47.6,104.34 49.2,102.74 49.2,93.84 v1(49.4,93.65) 49.2,93.44 49.2,88.8 48.16,87.76
  INNER2 w0.2: v1(86.8,93.79) 86.2,93.19 78.09,93.19 77.38,92.5 74.15,92.5 v1(72.85,93.79) 72.8,93.79 72.1,93.09 58.4,93.09 v1(57.85,93.65) 57.7,93.79 57.42,94.07 57.3,94.19 55.47,94.19 55.27,94 54.22,94 54.02,94.19 49.95,94.19 v1(49.4,93.65) 49.15,93.4 45.25,93.4 44.65,94 43.5,94 43.1,93.59 43.1,93.45 42.45,92.79 41.4,92.79 40.2,94 38.7,94 38.35,93.64 38.35,93.59 v1(38.15,93.4)
  BOTTOM w0.2: J7.164 87.85,96.5 86.8,95.44 v1(86.8,93.79) ; J7.14 39.25,96.85 38.15,95.75 v1(38.15,93.4) ; v1(57.85,93.65) 57.05,94.44 57.05,95.85 57.85,96.65 J7.64 ; v1(72.85,93.79) J7.114
MEMORY.RA14: length 128.8
  TOP w0.102: U1.T7 v2(48.9,86.94)
  TOP w0.2: U47.3 105.99,111.12 105.36,110.5 100.7,110.5 100.07,111.12 U46.3 94.58,111.12 93.96,110.5 90.2,110.5 90.05,110.65 88.6,110.65 v1(88.15,111.09) 85.71,111.09 U45.3 84.16,111.12 83.53,110.5 78.27,110.5 77.64,111.12 U44.3 72.88,111.12 v1(72.85,111.09) 72.25,110.5 69.8,110.5 69.17,111.12 U43.3 61.83,111.12 61.2,110.5 58.69,110.5 58.65,110.54 56.6,110.54 v1(56.2,110.94) 56.02,111.12 U42.3 51.42,111.12 50.79,110.5 v1(47.4,110.5) 46.5,110.5 45.87,111.12 U41.3 40.08,111.12 v1(39.92,110.97) 39.45,110.5 34.61,110.5 33.98,111.12 U40.3
  INNER1 w0.102: 48.9,87.76 v2(48.9,86.94)
  INNER1 w0.2: 48.9,87.76 48.9,87.94 49.6,88.64 49.6,93 50,93.4 50,93.99 49.6,94.39 49.6,102.99 47.75,104.84 47.4,104.84 47.02,105.22 47.02,105.77 47.3,106.04 48.05,106.04 48.48,106.48 48.48,109.41 v1(47.4,110.5)
  BOTTOM w0.2: J7.15 39.55,108.9 39.92,109.27 v1(39.92,110.97) ; J7.65 58.15,107.29 57.95,107.5 57.76,107.5 57.43,107.82 57.38,107.82 56.8,108.4 56.8,110.34 v1(56.2,110.94) ; v1(72.85,111.09) 73.15,110.79 J7.115 ; J7.165 88.15,107.29 88.35,107.5 88.35,110.9 v1(88.15,111.09)
MEMORY.RA15: length 191
  TOP w0.102: U1.T6 v2(49.9,86.94)
  TOP w0.2: U40.31 38.23,112.38 39.83,112.38 40.47,113.02 44.88,113.02 45.51,112.4 U41.31 49.15,112.38 50.74,112.38 51.41,113.04 54.1,113.04 54.1,113.04 v1(55.45,113.04) 56.25,113.04 56.9,112.4 U42.31 60.06,112.38 61.66,112.38 62.3,113.02 66.71,113.02 67.34,112.4 U43.31 70.97,112.38 72.08,112.38 72.75,113.04 76.56,113.04 76.6,113 77.65,113 78.25,112.4 U44.31 81.89,112.38 83.49,112.38 84.13,113.02 86.82,113.02 86.85,113.04 v1(87.55,113.04) 88.52,113.04 89.17,112.4 U45.31 92.8,112.38 94.4,112.38 95.04,113.02 99.46,113.02 100.08,112.4 U46.31 105.05,112.4 105.68,113.02 110.73,113.02 111.35,112.4 U47.31
  INNER1 w0.102: v2(49.9,86.94) 49.9,87.24 50.42,87.76
  INNER1 w0.2: v1(87.55,113.04) 87.2,112.69 87.2,111.2 88.15,110.25 88.15,102.69 87.75,102.29 87.75,99.34 88.3,98.79 v1(88.3,94.59) ; 50.42,87.76 50.65,87.99 v1(50.65,91.05) 51.55,91.95 51.55,92.44 51.35,92.64 51.35,107.29 55.45,111.4 v1(55.45,113.04)
  INNER2 w0.2: v1(58.75,93.69) 60.3,95.25 69.4,95.25 70.25,94.4 73.15,94.4 v1(73.75,93.79) 74.35,94.4 79.9,94.4 80.72,95.22 87.68,95.22 v1(88.3,94.59) ; v1(50.65,91.05) 49.45,92.25 41.35,92.25 40.2,93.4 v1(38.95,93.4)
  BOTTOM w0.2: v1(58.75,93.69) 58.2,94.25 57.85,94.25 57.45,94.65 57.45,95.65 58.45,96.65 J7.66 ; v1(88.3,94.59) 88.45,94.75 J7.166 ; v1(73.75,93.79) 73.45,94.09 J7.116 ; v1(38.95,93.4) 38.95,95.75 39.85,96.65 J7.16
MEMORY.RA16: length 106.4
  TOP w0.2: U47.2 106,112.4 105.38,111.77 100.07,111.77 99.45,112.4 U46.2 95.07,112.4 94.45,111.77 90.77,111.77 90.6,111.94 88.98,111.94 88.53,112.4 v1(88.15,112.4) U45.2 84.16,112.4 83.53,111.77 78.25,111.77 77.62,112.4 U44.2 v1(73.05,112.4) 72.41,111.75 67.91,111.75 67.9,111.75 67.36,111.75 66.71,112.4 U43.2 62.33,112.4 61.7,111.77 v1(56.42,111.77) 55.33,111.77 54.7,112.4 U42.2 51.42,112.4 50.79,111.77 45.5,111.77 44.88,112.4 U41.2 40.5,112.4 v1(39.88,111.77) 34.59,111.77 33.96,112.4 U40.2
  BOTTOM w0.2: v1(56.42,111.77) 57.2,110.99 57.2,108.59 57.57,108.22 57.6,108.22 57.72,108.09 58.4,108.09 58.75,107.75 J7.67 ; v1(88.15,112.4) 88.75,111.79 J7.167 ; J7.17 40.15,108.8 40.55,109.2 40.55,111.25 40.02,111.77 v1(39.88,111.77) ; v1(73.05,112.4) 73.75,111.69 J7.117
MEMORY.RD0: length 296.3
  TOP w0.102: U1.R15 v2(39.9,85.94)
  TOP w0.2: v1(29.12,98.43) U40.13 32.67,98.43 33.3,97.79 39.5,97.79 40.13,98.43 U41.13 44.9,98.43 45.52,97.8 50.95,97.8 51.58,98.43 U42.13 55.81,98.43 56.44,97.8 61.91,97.8 62.35,98.25 63.67,98.25 U43.13 66.73,98.43 67.35,97.8 72.62,97.8 73.24,98.43 U44.13 77.47,98.43 78.09,97.8 83.53,97.8 84.16,98.43 U45.13 86.83,98.43 88.05,99.65 v1(88.35,99.65) 88.55,99.65 90.4,97.8 94.81,97.8 95.43,98.43 U46.13 99.47,98.43 100.09,97.8 105.36,97.8 105.99,98.43 U47.13 110.63,98.43 111.26,97.8 118.71,97.8 121.67,100.77 132.15,100.77
  TOP w0.4: 132.15,100.77 161,100.77 arc(168.57,97.63) 171.7,90.07 171.7,79.34 arc(168.57,71.78) 161,68.65 157.65,68.65 arc(152.49,66.51) 150.35,61.34 150.35,46.39 150.7,46.04 P2.6
  INNER1 w0.102: 39.35,87.76 39.35,86.5 v2(39.9,85.94)
  INNER1 w0.2: 39.35,87.76 39.35,88.59 38.35,89.59 33,89.59 29.7,92.9 29.7,97.84 v1(29.12,98.43) ; v1(88.35,99.65) 89,99 89,94.34 88.65,94 87.85,94 87.4,94.44 77.65,94.44 76.9,93.69 v1(74.6,93.69) 74.6,93.79 74,94.4 72.3,94.4 71.05,93.15 60.25,93.15 v1(59.65,93.75)
  BOTTOM w0.1: v2(39.9,85.94) 39.58,86.26 39.58,87.76
  BOTTOM w0.2: 39.58,87.76 39.58,95.81 40.45,96.68 J7.18 ; J7.68 59.05,96.65 57.9,95.5 57.9,95 58.25,94.65 58.75,94.65 v1(59.65,93.75) ; J7.168 89.05,98.94 v1(88.35,99.65) ; v1(74.6,93.69) 74.6,93.79 74.05,94.34 J7.118
MEMORY.RD1: length 336.1
  TOP w0.102: U1.R16 v2(38.9,85.94)
  TOP w0.2: v1(29.1,97.15) 29.11,97.16 U40.14 32.64,97.16 33.27,96.53 39.48,96.53 40.11,97.16 U41.14 44.92,97.16 45.54,96.53 50.88,96.53 51.51,97.16 U42.14 55.72,97.16 56.34,96.53 62.03,96.53 62.66,97.16 U43.14 66.75,97.16 67.37,96.53 72.62,96.53 73.24,97.16 U44.14 77.29,97.16 77.91,96.53 83.88,96.53 84.51,97.16 U45.14 88.57,97.16 89.2,96.53 94.73,96.53 95.36,97.16 U46.14 99.49,97.16 100.11,96.53 v1(102.15,96.53) 105.36,96.53 105.99,97.16 U47.14 110.66,97.16 111.3,96.51 119.37,96.51 121.62,98.77 132.15,98.77
  TOP w0.4: 132.15,98.77 161,98.77 arc(167.15,96.22) 169.7,90.07 169.7,79.34 arc(167.15,73.19) 161,70.65 157.65,70.65 arc(151.07,67.92) 148.35,61.34 148.35,45.88 148.25,45.78 P2.4
  INNER1 w0.102: 38.55,87.76 38.52,87.73 38.52,86.33 v2(38.9,85.94)
  INNER1 w0.2: v1(29.1,97.15) 29.1,92.84 32.75,89.19 38.15,89.19 38.55,88.79 38.55,87.76
  INNER2 w0.2: v1(90.1,111.25) 88.95,111.25 88.45,111.75 87.55,111.75 86.95,112.34 79.25,112.34 v1(78.55,113.04) 76.9,113.04 75.65,111.79 72.8,111.79 72.55,112.04 57.85,112.04 56.8,110.99 56.8,104.29 57,104.09 v1(57,103.5) 53.75,103.5 53.15,102.9 49.3,102.9 48.65,103.54 40.95,103.54 v1(40.4,104.09)
  BOTTOM w0.2: v1(102.15,96.53) 102.15,98.13 99.45,100.83 99.45,102.9 100.15,103.59 100.15,109.54 98.45,111.25 91.13,111.25 v1(90.1,111.25) 89.2,110.35 89.2,108.65 89.35,108.5 J7.169 ; v1(78.55,113.04) 76.9,113.04 74.35,110.5 J7.119 ; J7.69 59.35,104.9 59.15,104.69 57.4,104.69 57,104.29 v1(57,103.5) ; J7.19 40.75,104.44 v1(40.4,104.09)
MEMORY.RD2: length 231
  TOP w0.102: U1.R14 v2(40.9,85.94)
  TOP w0.2: U40.15 34.76,95.88 v1(35.35,95.29) 35.4,95.25 39.86,95.25 v1(40.18,95.56) 40.5,95.88 U41.15 44.89,95.88 45.52,95.26 50.79,95.26 51.42,95.88 U42.15 55.8,95.88 56.45,95.25 v1(58.55,95.25) 62.05,95.25 62.69,95.88 U43.15 66.72,95.88 67.36,95.25 72.55,95.25 73.19,95.88 U44.15 75.96,95.88 76.7,95.15 v1(76.9,95.15) 77.9,95.15 78,95.25 83.9,95.25 84.54,95.88 U45.15 88.55,95.88 89.19,95.25 v1(89.65,95.25) 94.7,95.25 95.34,95.88 U46.15 99.46,95.88 100.09,95.26 105.36,95.26 105.99,95.88 U47.15 110.63,95.88 111.27,95.25 119.75,95.25 121.27,96.77 132.15,96.77
  TOP w0.4: P2.2 145.75,46.11 146.35,46.71 146.35,61.34 arc(149.66,69.34) 157.65,72.65 161,72.65 arc(165.74,74.61) 167.7,79.34 167.7,90.07 arc(165.74,94.8) 161,96.77 132.15,96.77
  INNER1 w0.102: v2(40.9,85.94) 40.4,86.44 40.4,87.76
  INNER1 w0.2: 40.4,87.76 40.4,88.15 38.55,90 36.4,90 35.35,91.04 v1(35.35,95.29)
  BOTTOM w0.2: J7.20 41.05,96.43 v1(40.18,95.56) ; J7.70 59.65,96.34 v1(58.55,95.25) ; J7.120 74.65,96.34 75.85,95.15 v1(76.9,95.15) ; J7.170 v1(89.65,95.25)
MEMORY.RD3: length 310.4
  TOP w0.1: U1.T15 39.9,86.94
  TOP w0.102: 39.9,86.94 39.9,87.76
  TOP w0.2: 132.15,95.77 121.17,95.77 120,94.59 114.63,94.59 U47.17 111.33,94.62 110.71,95.24 105.91,95.24 105.28,94.62 U46.17 101.52,94.62 v1(101.5,94.59) 100.1,94.59 99.46,95.24 95.4,95.24 94.75,94.59 92.8,94.59 U45.17 90.96,94.62 90.94,94.59 89.19,94.59 88.54,95.24 84.5,95.24 83.85,94.59 81.89,94.59 U44.17 81.8,94.54 76.65,94.54 75.95,95.24 73.39,95.24 72.75,94.59 70.97,94.59 U43.17 70.94,94.59 67.36,94.59 66.71,95.24 62.7,95.24 62.05,94.59 60.06,94.59 U42.17 56.33,94.62 55.7,95.24 51.45,95.24 50.85,94.65 49.16,94.65 U41.17 46.13,94.62 46.1,94.65 45.6,94.65 45.57,94.62 45.51,94.62 44.88,95.24 40.71,95.24 40.06,94.59 38.23,94.59 U40.17 38.2,94.6 37.75,94.6 37.55,94.4 37.55,90.84 39.9,88.5 39.9,87.76
  TOP w0.4: P2.1 144.5,46.27 145.35,47.12 145.35,61.34 arc(148.95,70.04) 157.65,73.65 161,73.65 arc(165.03,75.31) 166.7,79.34 166.7,90.07 arc(165.03,94.1) 161,95.77 132.15,95.77
  INNER2 w0.2: v1(40.35,101.59) 52.9,101.59 54.2,102.9 57.25,102.9 57.65,103.29 v1(57.65,104.09) 57.2,104.54 57.2,109.65 57.99,110.44 75.14,110.44 v1(76.45,111.75) 77.7,111.75 78.9,110.54 87.85,110.54 88.25,110.15 89.7,110.15 v1(89.85,110)
  BOTTOM w0.2: J7.171 89.95,109.9 v1(89.85,110) 89.85,110.09 90.6,110.85 90.97,110.85 90.97,110.84 98.28,110.84 99.65,109.48 99.65,103.66 99.05,103.06 99.05,100.66 101.5,98.21 v1(101.5,94.59) ; J7.121 74.95,110.25 v1(76.45,111.75) ; J7.21 41.35,102.59 v1(40.35,101.59) ; J7.71 59.95,104.84 59.35,104.25 57.8,104.25 v1(57.65,104.09)
MEMORY.RD4: length 233.4
  TOP w0.102: U1.T14 v2(40.9,86.94)
  TOP w0.2: 132.15,97.77 121.47,97.77 119.59,95.88 U47.18 111.36,95.88 110.73,96.51 106.02,96.51 105.4,95.88 U46.18 100.08,95.88 99.46,96.51 95.37,96.51 94.72,95.87 92.8,95.87 U45.18 ; U45.18 90.26,95.88 v1(90.25,95.9) 90.24,95.88 89.17,95.88 88.54,96.51 84.52,96.51 83.87,95.87 81.89,95.87 U44.18 76.91,95.88 v1(76.85,95.94) 76.28,96.51 73.22,96.51 72.57,95.87 70.97,95.87 U43.18 70.94,95.9 69,95.9 68.99,95.88 67.34,95.88 66.71,96.51 62.66,96.51 62.02,95.87 v1(61.75,95.87) 60.06,95.87 U42.18 56.42,95.88 55.8,96.51 51.43,96.51 50.79,95.87 49.15,95.87 U41.18 45.51,95.88 44.88,96.51 40.28,96.51 39.63,95.87 38.23,95.87 U40.18 38.2,95.9 v1(36.2,95.9) ; U45.18 92.77,95.9
  TOP w0.4: P2.3 147,45.94 147.35,46.29 147.35,61.34 arc(150.37,68.63) 157.65,71.65 161,71.65 arc(166.44,73.9) 168.7,79.34 168.7,90.07 arc(166.44,95.51) 161,97.77 132.15,97.77
  INNER1 w0.102: 40.9,87.76 v2(40.9,86.94)
  INNER1 w0.2: v1(36.2,95.9) 36.2,90.9 36.7,90.4 38.75,90.4 40.9,88.25 40.9,87.76
  BOTTOM w0.1: 41.65,87.76 41.65,87.69 v2(40.9,86.94)
  BOTTOM w0.2: J7.172 v1(90.25,95.9) ; v1(61.75,95.87) 60.68,95.87 60.25,96.29 J7.72 ; J7.122 75.25,96.69 76,95.94 v1(76.85,95.94) ; 41.65,87.76 41.6,87.81 41.6,93.64 41.65,93.69 J7.22
MEMORY.RD5: length 323.8
  TOP w0.102: U1.T13 v2(41.9,86.94)
  TOP w0.2: 132.15,99.77 121.67,99.77 119.06,97.16 U47.19 111.34,97.16 110.71,97.78 105.91,97.78 105.53,97.4 105.51,97.4 105.27,97.16 U46.19 103.69,97.15 v1(100.75,97.15) 100.09,97.15 99.46,97.78 95.38,97.78 94.74,97.13 92.8,97.13 U45.19 89.17,97.16 88.54,97.78 84.13,97.78 83.55,97.19 81.91,97.19 U44.19 78.04,97.16 77.41,97.78 73.22,97.78 72.57,97.13 70.97,97.13 U43.19 67.34,97.16 66.71,97.78 62.63,97.78 61.99,97.13 60.06,97.13 U42.19 56.42,97.16 55.8,97.78 51.5,97.78 50.86,97.13 49.15,97.13 U41.19 45.51,97.16 44.88,97.78 40.13,97.78 39.49,97.13 38.23,97.13 U40.19 ; 38.2,97.15 U40.19 ; U40.19 35.76,97.16 35.75,97.15 v1(34.85,97.15)
  TOP w0.4: P2.5 149.45,45.88 149.35,45.98 149.35,61.34 arc(151.78,67.21) 157.65,69.65 161,69.65 arc(167.86,72.49) 170.7,79.34 170.7,90.07 arc(167.86,96.93) 161,99.77 132.15,99.77
  INNER1 w0.1: 41.9,87.76 v2(41.9,86.94)
  INNER1 w0.2: v1(34.85,97.15) 36.05,97.15 36.8,96.4 36.8,91.09 37.05,90.84 38.95,90.84 41.9,87.9 41.9,87.76 ; v1(57.9,108.75) 57.05,109.59 57.05,113.19 56.55,113.69 55.1,113.69 53.17,111.76 46.55,111.76 46.53,111.75 v1(44.25,111.75)
  INNER2 w0.2: v1(57.9,108.75) 59.3,108.75 59.95,108.09 66.45,108.09 69.75,104.79 75.65,104.79 v1(76.4,104.04) 77.45,105.09 99,105.09 v1(99.05,105.15)
  BOTTOM w0.2: J7.73 60.55,107.54 59.35,108.75 v1(57.9,108.75) ; J7.173 90.55,108.5 90.45,108.59 90.45,110.09 90.8,110.44 98.12,110.44 99.05,109.51 v1(99.05,105.15) 99.05,103.63 98.65,103.23 98.65,100.5 100.75,98.39 v1(100.75,97.15) ; v1(76.4,104.04) 76.15,104.29 75.7,104.29 75.55,104.44 J7.123 ; v1(44.25,111.75) 42.6,110.09 42.6,108.09 41.95,107.44 J7.23
MEMORY.RD6: length 248.3
  TOP w0.102: U1.R12 v2(42.9,85.94)
  TOP w0.15: 61.92,98.41 62.81,99.07
  TOP w0.2: 38.19,98.44 U40.20 ; U40.20 v1(34.87,98.43) ; U40.20 38.23,98.41 39.51,98.41 40.16,99.05 44.88,99.05 45.51,98.43 U41.20 49.15,98.41 50.91,98.41 51.55,99.05 55.35,99.05 55.8,99.5 v1(56.6,99.5) 57.67,98.43 U42.20 60.06,98.41 61.92,98.41 ; 132.15,101.77 121.87,101.77 118.53,98.43 U47.20 111.37,98.43 110.75,99.05 105.97,99.05 105.34,98.43 U46.20 100.08,98.43 99.46,99.04 97.76,99.04 97.76,99.05 95.44,99.05 94.79,98.41 92.8,98.41 U45.20 90.67,98.43 v1(89.35,99.75) 88.85,100.25 88.05,100.25 86.85,99.05 84.13,99.05 83.49,98.41 81.89,98.41 U44.20 78.75,98.43 77.33,99.84 v1(77.05,99.84) 76.8,99.84 76,99.05 73.22,99.05 72.57,98.41 70.97,98.41 U43.20 67.34,98.43 66.69,99.07 62.81,99.07
  TOP w0.4: 132.15,101.77 161,101.77 arc(169.27,98.34) 172.7,90.07 172.7,79.34 arc(169.27,71.07) 161,67.65 157.65,67.65 arc(153.2,65.8) 151.35,61.34 151.35,46.81 151.95,46.21 P2.7
  INNER1 w0.1: 43.4,87.76 43.4,86.84 42.9,86.34 v2(42.9,85.94)
  INNER1 w0.2: v1(42.2,93.4) 43.4,92.19 43.4,87.76
  INNER2 w0.2: v1(34.87,98.43) 41.42,98.43 42.2,97.65 v1(42.2,93.4)
  BOTTOM w0.2: v1(42.2,93.4) 42.2,97.84 J7.24 ; J7.174 90.85,99.29 90.4,99.75 v1(89.35,99.75) ; v1(77.05,99.84) 76.4,99.84 75.85,99.29 J7.124 ; J7.74 60.85,99.29 60.65,99.5 59.06,99.5 58.93,99.62 57.97,99.62 57.84,99.5 v1(56.6,99.5)
MEMORY.RD7: length 260.3
  TOP w0.102: U1.T12 v2(42.9,86.94)
  TOP w0.2: v1(35.55,99.84) 35.7,99.69 U40.21 38.23,99.68 39.58,99.68 40.22,100.32 v1(43.53,100.32) 44.88,100.32 45.51,99.69 U41.21 49.15,99.68 50.98,99.68 51.64,100.34 54.1,100.34 54.3,100.54 57.15,100.54 58,99.69 U42.21 60.06,99.68 61.18,99.68 61.84,100.34 61.85,100.34 62.35,100.34 62.35,100.34 65.15,100.34 65.9,101.09 v1(66.05,101.09) 67.35,101.09 68.9,99.54 70.81,99.54 U43.21 70.97,99.68 72.57,99.68 73.24,100.34 75.94,100.34 76.6,101 77.6,101 v1(78.25,100.34) 79,100.34 79.65,99.69 U44.21 81.89,99.68 83.49,99.68 84.15,100.34 86.84,100.34 87.55,101.04 89.52,101.04 90.87,99.69 U45.21 ; 92.8,99.68 U45.21 ; U45.21 v1(94.4,99.69) 95.03,100.32 97.91,100.32 98.23,100.65 99.35,100.65 100.3,99.69 U46.21 105.28,99.69 105.91,100.32 110.73,100.32 111.35,99.69 U47.21 118.85,99.69 121.92,102.77 132.15,102.77
  TOP w0.4: 132.15,102.77 161,102.77 arc(169.98,99.05) 173.7,90.07 173.7,79.34 arc(169.98,70.36) 161,66.65 157.65,66.65 arc(153.9,65.09) 152.35,61.34 152.35,47.22 153.2,46.37 P2.8
  INNER1 w0.102: 42.9,87.59 v2(42.9,86.94)
  INNER1 w0.2: v1(35.55,99.84) 37.2,98.19 37.2,91.5 37.4,91.29 39.2,91.29 42.9,87.59
  BOTTOM w0.2: J7.75 61.15,103.19 61.7,102.65 64.5,102.65 v1(66.05,101.09) ; J7.125 76.15,104.9 76.4,104.65 77.15,104.65 78.25,103.54 v1(78.25,100.34) ; v1(43.53,100.32) 43.53,103.62 42.55,104.59 J7.25 ; v1(94.4,99.69) 93.6,100.5 93.6,102.5 92.5,103.59 92.5,104.29 92.1,104.69 91.45,104.69 91.15,105 J7.175
MRD/: length 17.3
  TOP w0.2: U7.8 11.94,30.73 11.61,30.41 10.51,30.41 9.5,31.42 6.77,31.42 5.25,32.95 4.51,32.95 4.02,33.44 4.02,34.15 4.87,35 J6.E4
MWR/: length 21.4
  TOP w0.2: J6.E5 4.87,38.86 4.02,38.01 4.02,34.72 3.62,34.31 3.62,33.28 4.35,32.55 5.08,32.55 8.28,29.34 10.29,29.34 10.51,29.57 11.58,29.57 12.26,28.88 13.14,28.88 13.72,29.46 U7.9
N00036_USER_DESIGN_OUTPUTS0_D_1: length 39.4
  TOP w0.2: 93.45,10.72 U32.8 90.88,10.72 90.79,10.8 88.16,10.8 87.7,10.35 87.7,2.15 89.05,0.8 96.25,0.8 96.68,1.22 L8.2 98.38,2.74 R54.1 ; 93.45,10.72 93.75,11.02 93.75,12.72 94,12.97 95.44,12.97 95.45,12.95 v1(97.13,12.95) ; 93.45,10.72 93.45,7.5 92.86,6.91 U32.5
  BOTTOM w0.2: R53.1 97.12,12.94 v1(97.13,12.95)
N00036_USER_DESIGN_OUTPUTS0_DAA: length 33.7
  TOP w0.2: R56.1 98.38,18.22 L10.2 96.7,18.2 96.7,16.5 96.04,15.84 90.75,15.84 89.75,16.85 89.75,21.35 89.75,21.35 89.75,22.39 ; 89.75,22.39 U35.5 ; 89.75,22.39 89.75,25.64 90.3,26.2 U35.8 93.45,26.2 93.75,26.5 93.75,28.2 94,28.45 95.44,28.45 95.45,28.43 v1(97.13,28.43)
  BOTTOM w0.2: v1(97.13,28.43) 95.54,28.43 R55.1
N00038_USER_DESIGN_OUTPUTS0_D_1: length 5.5
  TOP w0.2: v1(90.64,5.64) 90.99,5.64 91.02,5.67 92.1,5.67 U32.4 92.16,5.67 93.25,5.67 93.28,5.64 94.08,5.64 94.39,5.94
  BOTTOM w0.2: C198.1 91.83,5.64 v1(90.64,5.64)
N00038_USER_DESIGN_OUTPUTS0_DAA: length 6.1
  TOP w0.2: v1(90.35,21.09) 92.11,21.09 U35.4 94.08,21.12 L9.2
  BOTTOM w0.2: v1(90.35,21.09) 90.68,21.42 92.13,21.42
N00044_USER_DESIGN_OUTPUTS0_D_1: length 6.6
  TOP w0.2: v1(102.3,27.09) 102.3,24.95 101.95,24.59 100.46,24.59 U36.1
  BOTTOM w0.2: U37.2 102.89,27.68 v1(102.3,27.09)
N00044_USER_DESIGN_OUTPUTS0_DAA: length 6.6
  TOP w0.2: U33.1 100.46,9.12 101.95,9.12 102.3,9.47 v1(102.3,11.62)
  BOTTOM w0.2: v1(102.3,11.62) 102.89,12.21 U34.2
N00046_USER_DESIGN_OUTPUTS0_D_1: length 9.2
  TOP w0.2: 95.45,9.14 97.05,9.14 100.48,5.71 R54.2
N00046_USER_DESIGN_OUTPUTS0_DAA: length 9.2
  TOP w0.2: R56.2 100.5,18.44 100.5,21.05 96.93,24.62 95.45,24.62
N00048_USER_DESIGN_OUTPUTS0_D_1: length 5.2
  TOP w0.2: U33.2 98.5,10.41 97.87,11.04 v1(97.45,11.04)
  BOTTOM w0.2: v1(97.45,11.04) 97.25,11.04 97.22,11.02 95.61,11.02 R53.2
N00048_USER_DESIGN_OUTPUTS0_DAA: length 5.1
  TOP w0.2: U36.2 98.5,25.89 v1(97.95,26.45)
  BOTTOM w0.2: v1(97.95,26.45) 97.93,26.42 R55.2
N00060_USER_DESIGN_OUTPUTS0_D_1: length 12.6
  TOP w0.2: U35.6 v1(93.76,23.66)
  BOTTOM w0.2: v1(93.76,23.66) 101.57,23.66 103.79,25.88
N00060_USER_DESIGN_OUTPUTS0_DAA: length 15.4
  TOP w0.2: v1(90.75,8.2) 90.77,8.18 U32.6
  BOTTOM w0.2: v1(90.75,8.2) 90.77,8.18 101.57,8.18 103.79,10.4
Net_650: length 3.7
  TOP w0.2: 74.77,113.66 76.87,113.66 v1(77.4,114.19)
  INNER1 w0.2: v1(77.4,114.19) 78.25,114.19
PGOOD: length 2.6
  TOP w0.2: U51.9 74.91,35.04 v1(75.15,35.29)
  BOTTOM w0.2: R2012.2 74.66,34.31 75.15,34.79 v1(75.15,35.29)
Q1E: length 3.1
  TOP w0.5: Q9.2 111.77,80.03 R52.2
Q2E: length 7.2
  TOP w0.5: R45.1 96.5,89.2 C68.2 97.81,89.15 R47.2 98.58,88.31 Q8.2
RDY/: length 23.3
  TOP w0.2: v1(21.55,40.24) 23.44,38.35 U7.19
  INNER2 w0.2: v1(21.55,40.24) 21.53,40.23 13.72,40.23 11.55,42.4 10.4,42.4 9.42,41.41 J6.E6
RESET: length 75.1
  TOP w0.102: U1.M12 v2(42.9,82.94) ; U2.T11 v2(62.25,39.9)
  TOP w0.2: v1(61.5,34.84) 61.7,35.04 U50.11 ; v1(62.45,28.7) 63.6,28.7 U49.2
  INNER1 w0.1: 44.5,70.49 44.5,80.48 42.9,82.08 v2(42.9,82.94) ; 53.73,56.41 53.75,56.4 53.75,54.2 54.65,53.3 54.65,52.74 55,52.4 55.9,52.4 57.75,50.55 57.75,40.49 58.35,39.9 v2(62.25,39.9)
  INNER1 w0.2: 53.73,56.41 52.9,57.24 50.9,57.24 49.7,58.45 49.7,64.44 48.8,65.34 48.8,68.44 47.85,69.4 45.1,69.4 44.5,70 44.5,70.49
  BOTTOM w0.1: v2(62.25,39.9) 62.9,39.24
  BOTTOM w0.2: 62.9,39.24 63.15,38.99 63.15,38.53 63.15,38.53 63.15,37.86 63.15,37.86 63.15,36.14 61.85,34.84 v1(61.5,34.84) 61.42,34.77 61.42,29.73 v1(62.45,28.7) 62.95,28.7 63.52,29.26 R2008.2
RESET/: length 16.9
  TOP w0.2: J6.E1 4.9,28.68 4.9,24.8 6.25,23.45 13.55,23.45 15.15,21.84 U48.3
SEL: length 21.8
  TOP w0.2: U48.9 16.66,14.25 20.75,14.25 22.9,16.39 22.9,27.7 23.4,28.19 U7.11
STDA_SSRX+: length 71.8
  TOP w0.102: U2.A8 v2(58.25,55.9)
  BOTTOM w0.102: 59.6,56.54 59.58,56.52 59.58,56.51 58.56,55.49 58.25,55.8 v2(58.25,55.9)
  BOTTOM w0.127: R2002.2 116.3,69.5 116.3,68.9 116.21,68.8 114.3,68.8 114.3,69.28 C2003.1 113.55,70.03 113.55,70.32 113.28,70.59 105.62,70.59 105.2,70.18 105.2,62.2 102.78,59.78 84.66,59.78 84.45,59.78 82.77,58.1 61.15,58.1 59.6,56.54
STDA_SSRX-: length 72.7
  TOP w0.102: U2.B8 v2(58.25,54.9)
  BOTTOM w0.102: v2(58.25,54.9) 58.29,54.9 59.74,56.34 59.76,56.34 59.78,56.36
  BOTTOM w0.127: 114.2,68.55 114.2,67.97 C2002.1 ; 114.2,68.55 116.2,68.55 116.3,68.44 116.3,67.86 R2003.2 ; 114.2,68.55 114.19,68.55 114,68.74 113.5,68.74 113.34,68.89 113.34,69.1 113.3,69.15 113.3,70.21 113.17,70.34 105.72,70.34 105.45,70.07 105.45,62.09 102.89,59.52 84.55,59.52 82.88,57.84 61.26,57.84 59.78,56.36
STDA_SSTX+: length 68.5
  TOP w0.102: U2.E7 v2(57.25,51.9)
  BOTTOM w0.1: 60.47,56.23 60.45,56.22 60.44,56.22 58.73,54.51 58.73,53.75 58.73,53.75
  BOTTOM w0.102: v2(57.25,51.9) 57.7,51.9 58.09,51.51 58.41,51.51 58.63,51.73 58.63,52.05 58.41,52.28 58.25,52.28 57.93,52.6 57.93,52.95 58.73,53.75
  BOTTOM w0.127: R2005.2 116.3,61.25 116.3,61.84 116.2,61.94 114.25,61.94 114.25,61.41 C2004.1 113.97,61.25 113.6,60.87 113.6,60.74 113.8,60.54 113.8,59.54 113.21,58.94 84.8,58.94 83.12,57.26 61.5,57.26 60.47,56.23
STDA_SSTX-: length 67.9
  TOP w0.102: U2.E8 v2(58.25,51.9)
  BOTTOM w0.1: 58.5,53.85 58.5,54.6 60.23,56.33 60.23,56.33 60.28,56.39 60.28,56.41 60.29,56.41
  BOTTOM w0.102: 58.5,53.85 57.7,53.05 57.7,52.45 v2(58.25,51.9)
  BOTTOM w0.127: 114.1,62.2 113.91,62.01 113.5,62.01 113.34,61.85 113.34,60.64 113.55,60.43 113.55,59.65 113.1,59.2 84.69,59.2 83.01,57.52 61.4,57.52 60.29,56.41 ; 114.1,62.2 116.2,62.2 116.3,62.3 116.3,62.89 R2004.2 ; 114.1,62.2 114.1,62.9 C2005.1
TCLK: length 80.2
  TOP w0.102: U2.C14 v2(65.25,53.9) ; U1.C14 v2(40.9,72.94)
  INNER2 w0.1: 64.87,56.41 64.87,54.27 v2(65.25,53.9) ; v2(40.9,72.94) 40.9,72 40.25,71.34 39.75,71.34 39.5,71.09 39.5,70.69 39.68,70.51 39.68,70.49
  INNER2 w0.2: 64.87,56.41 64.87,61.02 62.9,62.99 53.93,62.99 51.55,65.38 51.55,66.19 50.2,67.55 41.18,67.55 39.68,69.04 39.68,70.49
  BOTTOM w0.1: 61.3,39.24 60.67,39.88
  BOTTOM w0.102: v2(65.25,53.9) 64.87,53.51 64.87,45.36 64.23,44.73 62.15,44.73 61.65,44.23 61.65,43.7 61.45,43.49 60.9,43.49 60.9,43.45 60.67,43.22 60.67,39.88
  BOTTOM w0.2: 61.3,39.24 62.35,38.2 62.35,36.59 61.7,35.95 60.68,35.95 59.74,35 57.48,35 57.05,34.57 49.33,34.57 47.76,33 P1.3
TDO: length 44.7
  TOP w0.102: U1.E14 v2(40.9,74.94) ; U2.C12 v2(63.25,53.9)
  INNER2 w0.1: 63.63,56.41 63.63,54.27 v2(63.25,53.9) ; v2(40.9,74.94) 40.9,74.48 41.28,74.1 41.28,73.62 41.05,73.4 40.75,73.4 40.5,73.15 40.5,71.85 40.17,71.53 39.67,71.53 39.28,71.13 39.28,70.49
  INNER2 w0.2: 63.63,56.41 63.63,61.7 62.73,62.59 53.77,62.59 51.15,65.21 51.15,66.03 50.03,67.15 41.01,67.15 39.28,68.88 39.28,70.49
TMS: length 89.5
  TOP w0.102: U1.A15 v2(39.9,70.94) ; U2.A15 v2(66.25,55.9)
  INNER1 w0.102: v2(39.9,70.94) 39.9,70.49
  INNER1 w0.2: P1.11 37.6,32.95 35.65,34.89 30.05,34.89 29.05,35.89 29.05,60.05 35.46,66.45 39.26,66.45 39.9,67.09 39.9,70.49
  INNER2 w0.1: 40.1,70.49 40.1,70.75 v2(39.9,70.94) ; 66.25,56.41 v2(66.25,55.9)
  INNER2 w0.2: 66.25,56.41 66.25,60.24 63.1,63.4 54.1,63.4 51.95,65.55 51.95,66.4 50.4,67.94 41.5,67.94 40.1,69.34 40.1,70.49
V+12: length 94.7
  TOP w0.5: U29.L5 88.42,50.93 88.4,50.95 ; 107.2,50.95 107.22,50.93 U31.L5 ; v1(31.15,21.5) 30.62,20.96 U3.8 ; C39.2 86.51,90.86 R19.2 D5.1 91.82,90.86 92.32,91.36 94.5,91.36 ; 94.5,91.36 R45.2 ; 94.5,91.36 v1(94.5,92.29) ; 97.75,50.95 97.77,50.93 U30.L5 ; U5.1 v1(38.67,15.97) ; U36.4 v1(98.73,28.43) ; U33.4 v1(98.73,12.95)
  INNER2 w0.5: v1(94.5,92.29) 96.3,90.5 96.3,84.84 108.15,73 108.15,53.45 ; 12,29.11 J6.A2 ; J6.A2 13.23,29.11 ; J6.A2 12,30.35 ; J6.A2 13.23,30.35 ; J6.D1 7.23,28.32 ; J6.D1 7.23,27.08 ; J6.D1 6,28.32 ; J6.D1 6,27.08 ; U37.7 109.66,25.09 ; U37.7 107.83,25.88 ; U37.7 109.66,26.67 ; 6,29.11 J6.D2 ; J6.D2 7.23,29.11 ; J6.D2 7.23,30.35 ; J6.D2 6,30.35 ; U34.7 109.66,9.62 ; U34.7 107.83,10.4 ; U34.7 109.66,11.19 ; J6.A1 13.23,27.08 ; J6.A1 12,28.32 ; J6.A1 12,27.08 ; J6.A1 13.23,28.32
  BOTTOM w0.5: v1(98.73,28.43) 99.12,28.82 C202.1 ; C33.2 29.67,21.5 v1(31.15,21.5) 32.18,21.5 C32.2 C31.2 ; v1(98.73,12.95) 99.12,13.34 C199.1
  vias: v1(87.3,47.24) v1(87.3,46.45) v1(88.1,47.24) v1(88.1,46.45) v1(94.9,48.95) v1(94.9,48.15) v1(95.7,48.95) v1(95.7,48.15) v1(103.5,49.15) v1(103.5,48.34) v1(104.3,49.15) v1(104.3,48.34)
VCLKC: length 3.6
  TOP w0.2: U39.11 v1(76.91,17.31)
  BOTTOM w0.2: R26.2 78.59,17.31 v1(76.91,17.31)
VDX0: length 127.5
  TOP w0.2: U48.11 v1(27.42,12.95) ; v1(67.66,3.1) U38.9 69.1,3.1 70.85,3.1 73.6,5.85 73.6,14.81 71.7,16.71 68.09,16.71 67.55,17.25 67.55,18.2 67.93,18.58 U39.9 73.58,18.58 77.25,22.25 77.25,29.3 78.65,30.7 92.95,30.7 97.7,35.45 100.1,35.45 U22.9 100.16,35.39 101.6,35.39 v1(101.8,35.59)
  INNER1 w0.2: v1(67.66,3.1) 32.25,3.1 27.42,7.93 v1(27.42,12.95)
  BOTTOM w0.2: RN2.5 103.07,36.87 v1(101.8,35.59) 100.15,35.59 96.6,32.05 R8.2
