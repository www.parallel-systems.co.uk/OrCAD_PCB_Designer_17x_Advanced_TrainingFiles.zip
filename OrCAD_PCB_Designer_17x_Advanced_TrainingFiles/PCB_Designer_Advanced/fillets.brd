# Allegro board fillets.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D1: length 36.4
  TOP w0.2: U8.27 25.59,64.39 24.5,64.39 24.3,64.59 v1(24.3,64.65) ; v1(24.32,53) 24.49,52.82 U9.38
  INNER2 w0.2: v1(24.32,53) 24.31,52.99 23.71,52.99 23.7,53 23.2,53 22.39,52.2 18.45,52.2 16.99,50.74 14.35,50.74 14.1,50.99 11.9,50.99 11.4,50.49 10.8,50.49 9.34,49.04 J6.E9
  BOTTOM w0.2: v1(24.32,53) 25.15,53.83 25.15,63.8 v1(24.3,64.65)
D2: length 37.7
  TOP w0.2: U9.40 25.49,53.84 v1(23.45,53.84) 22.8,53.84 21.84,54.8 21.84,63.44 23.85,65.44 24.74,65.44 24.79,65.39 25.59,65.39 U8.29
  INNER2 w0.2: v1(23.45,53.84) 22.61,53.84 22.31,54.15 21.7,54.15 21.3,54.55 18.15,54.55 17.4,53.8 15.9,53.8 14.3,52.2 11.45,52.2 11.22,52.42 10.31,52.42 9.46,51.58 J6.E10
D3: length 46.4
  TOP w0.2: v1(26.8,54.2) 26.67,54.32 U9.41 ; v1(22.2,53.4) 22.2,53.8 21.45,54.55 21.45,63.61 23.68,65.84 24.9,65.84 24.91,65.84 U8.30
  INNER1 w0.2: v1(22.2,53.4) 23.04,53.4 23.2,53.24 23.7,53.24 24.66,54.2 v1(26.8,54.2)
  INNER2 w0.2: J6.E11 9.66,54.12 11.64,56.09 13.25,56.09 14.13,55.22 16.23,55.22 16.44,55.42 18.23,55.42 18.9,56.09 20.33,56.09 21.88,54.55 23.49,54.55 23.6,54.44 24.21,54.44 24.5,54.15 26.75,54.15 v1(26.8,54.2)
D4: length 58.5
  TOP w0.2: U9.43 24.62,55.32 24.35,55.05 23.85,55.05 v1(23.85,55.04) 22.45,55.04 22.24,55.24 22.24,61.49 23.6,62.84 26.95,62.84 27.95,63.84 27.95,66.15 27.26,66.83 26.46,66.83 26.45,66.84 U8.32
  INNER2 w0.2: J6.E12 9.3,56.66 10.29,57.65 11.6,57.65 12.12,57.12 13.07,57.12 14.3,58.34 18.65,58.34 21.95,55.04 v1(23.85,55.04)
  BOTTOM w0.2: v1(23.85,55.04) 23.45,55.04 22.8,54.4 22.8,53.65 22.8,53.65 22.8,53.14 22.8,53.14 22.8,51.74 23.85,50.7 v1(23.85,40.4)
D5: length 42
  TOP w0.2: U9.44 v1(24.07,55.82) 24.05,55.8 22.99,55.8 22.64,56.14 22.64,61.32 23.77,62.45 27.12,62.45 28.35,63.68 28.35,66.4 27.51,67.23 26.62,67.23 26.52,67.34 U8.33
  INNER2 w0.2: J6.E13 9.37,59.2 9.57,58.99 9.57,58.99 10.22,58.34 11.45,58.34 12.3,59.2 19.2,59.2 22.55,55.84 24.05,55.84 v1(24.07,55.82)
D6: length 36.8
  TOP w0.2: U8.35 25.64,68.34 24.41,68.34 24.2,68.13 23.7,68.13 23.58,68.25 v1(23.3,68.25) ; v1(23.25,56.84) 23.3,56.8 25.49,56.8 U9.46
  INNER2 w0.2: v1(23.25,56.84) 19.03,61.06 11.91,61.06 11.7,60.84 10.3,60.84 9.41,61.73 J6.E14
  BOTTOM w0.2: v1(23.25,56.84) 23.25,68.19 v1(23.3,68.25)
D7: length 36.9
  TOP w0.2: v1(24.05,57.4) 24.1,57.34 25.49,57.34 U9.47 ; U8.36 25.64,68.84 24.06,68.84 23.95,68.74 v1(23.95,68.74)
  INNER2 w0.2: v1(24.05,57.4) 19.4,62.05 12.35,62.05 11.5,62.9 10.5,62.9 9.12,64.28 J6.E15
  BOTTOM w0.2: v1(23.95,68.74) 23.95,67.89 23.7,67.64 23.7,57.76 v1(24.05,57.4)
D8: length 30.3
  TOP w0.2: J6.E24 4.87,92.66 6.56,94.36 14.23,94.36 15.53,95.65 21.7,95.65 22.36,95 22.38,95 24.35,93.03 24.35,93.01 24.35,93.01 24.35,91.55 24.8,91.1 U6.47
D9: length 32.6
  TOP w0.2: U6.46 24.8,90.6 24.75,90.65 24.68,90.65 23.95,91.38 23.95,92.84 23.95,92.84 23.95,92.86 22.21,94.6 22.19,94.6 21.54,95.25 15.69,95.25 14.4,93.96 6.76,93.96 5.45,92.65 5.45,88.34 5.72,88.08 5.72,86.48 4.87,85.63 J6.E23
D10: length 34.1
  TOP w0.2: J6.E22 5.72,82.91 5.72,85.79 5.77,85.84 5.77,85.96 7.07,87.26 7.07,89.16 7.45,89.55 7.45,92.79 8.21,93.56 14.57,93.56 15.86,94.85 21.37,94.85 22.02,94.2 22.04,94.2 23.55,92.69 23.55,92.68 23.55,92.67 23.55,90.85 24.8,89.6 U6.44
D11: length 35.6
  TOP w0.2: U6.43 24.7,89.1 23.15,90.65 23.15,91.18 23.15,91.18 23.15,92.51 23.15,92.51 23.15,92.53 21.88,93.8 21.86,93.8 21.21,94.45 16.02,94.45 11.37,89.8 8.43,89.8 7.47,88.84 7.47,79.86 7,79.4 4.99,79.4 J6.E21
D12: length 38.1
  TOP w0.2: U6.41 24.73,88.1 22.75,90.08 22.75,91.35 22.75,91.35 22.75,92.34 22.75,92.34 22.75,92.36 21.71,93.4 21.69,93.4 21.04,94.05 16.19,94.05 11.54,89.4 8.6,89.4 7.87,88.67 7.87,77.69 7.15,76.97 J6.E20
D13: length 40.3
  TOP w0.2: J6.E19 5.01,74.29 7.05,74.29 8.27,75.51 8.27,88.5 8.76,89 11.7,89 16.36,93.65 20.88,93.65 22.35,92.18 22.35,91.51 22.35,91.51 22.35,89.91 24.66,87.6 U6.40
D14: length 33.7
  TOP w0.2: v1(24.15,87.17) 24.37,86.95 24.4,86.95 24.75,86.6 U6.38
  INNER1 w0.2: J6.E18 7,71.9 7.75,72.65 7.75,83.48 10.18,85.9 11.14,85.9 12.13,86.9 23.88,86.9 v1(24.15,87.17)
D15: length 35.8
  TOP w0.2: U6.37 24.39,86.1 v1(24.15,86.34)
  INNER1 w0.2: v1(24.15,86.34) 24.04,86.46 12.26,86.46 11.3,85.5 10.34,85.5 8.15,83.31 8.15,70.09 7.41,69.35 J6.E17
D+: length 78.1
  TOP w0.102: v2(61.27,42.92) U2.N11
  INNER1 w0.127: v1(114.73,58.8) 114.45,59.07 114.45,59.47 114.3,59.62 114.3,65.04 114.48,65.21 114.97,65.21 v1(115.25,64.94)
  BOTTOM w0.102: v2(61.27,42.92) 61.3,42.92 61.72,42.49 62.33,42.49 62.75,42.07 67.25,42.07 67.27,42.05 67.91,42.05 67.92,42.04 67.94,42.04
  BOTTOM w0.127: v1(114.73,58.8) 114.45,58.52 114.45,58.28 114.18,58.01 112.89,58.01 112.54,58.36 85.07,58.36 84.9,58.19 84.9,48.09 84.9,48.08 84.9,47.98 84.9,47.97 84.9,47.76 79.17,42.04 67.94,42.04 ; R2000.2 115.91,64.94 v1(115.25,64.94) 114.47,64.94 C2001.1
D-: length 77
  TOP w0.102: v2(62.25,42.9) 61.85,42.5 61.75,42.4 U2.P11
  INNER1 w0.127: v1(113.92,58.8) 114.2,59.07 114.2,59.36 114.05,59.51 114.05,65.15 114.37,65.47 114.97,65.47 v1(115.25,65.75)
  BOTTOM w0.102: v2(62.25,42.9) 62.85,42.3 67.94,42.3
  BOTTOM w0.127: C2000.1 114.54,65.75 v1(115.25,65.75) 115.84,65.75 R2001.2 ; v1(113.92,58.8) 114.2,58.52 114.2,58.39 114.07,58.26 113,58.26 112.65,58.61 84.97,58.61 84.65,58.3 84.65,48.2 84.64,48.19 84.64,47.87 79.07,42.3 67.94,42.3
DATA0+: length 27.3
  TOP w0.102: U1.B6 v2(49.9,71.94) ; U2.B5 v2(55.25,54.9)
  INNER1 w0.102: 54.85,56.41 54.85,55.76 55.25,55.35 v2(55.25,54.9) ; 49.48,70.49 49.48,71.08 49.9,71.5 v2(49.9,71.94)
  INNER1 w0.127: 54.85,56.41 54.85,61.46 54.19,62.12 52.47,62.12 51.4,63.2 51.4,64.46 52,64.46 52,64.72 51.3,64.72 51.3,65.55 52,65.55 52,65.95 51.4,65.95 51.4,66.79 52,66.79 52,67.12 51.4,67.12 51.4,67.95 52,67.95 52,68.28 51.4,68.28 51.4,69.09 50.49,69.99 49.97,69.99 49.48,70.49
DATA0-: length 24.9
  TOP w0.102: U1.A6 v2(49.9,70.94) ; U2.A5 v2(55.25,55.9)
  INNER1 w0.102: v2(49.9,70.94) 49.9,70.53 49.95,70.49 ; 55.1,56.41 55.1,56.4 55.09,56.39 55.09,56.31 55.08,56.3 55.08,56.07 v2(55.25,55.9)
  INNER1 w0.127: 49.95,70.49 50.19,70.25 50.6,70.25 51.65,69.19 51.65,68.53 52.25,68.53 52.25,67.7 51.65,67.7 51.65,67.37 52.25,67.37 52.25,66.53 51.65,66.53 51.65,66.21 52.25,66.21 52.25,65.3 51.55,65.3 51.55,64.97 52.25,64.97 52.25,64.21 51.65,64.21 51.65,63.3 52.58,62.38 54.29,62.38 55.1,61.56 55.1,56.41
DATA1+: length 27.2
  TOP w0.102: U2.D5 v2(55.25,52.9) ; U1.D6 v2(49.9,73.94)
  INNER1 w0.102: v2(55.25,52.9) 55.25,53.36 54.87,53.74 54.87,53.95 54.64,54.18 54.64,55.04 54.3,55.38 54.3,56.28 54.27,56.31 54.27,56.41 ; 48.9,70.49 48.9,71.26 49.28,71.65 49.28,72.93 49.9,73.54 v2(49.9,73.94)
  INNER1 w0.127: 48.9,70.49 48.9,70 49.5,69.39 50.12,69.39 50.25,69.26 50.25,63.04 51.74,61.54 53.94,61.54 54.27,61.22 54.27,56.41
DATA1-: length 24.9
  TOP w0.102: U1.C6 v2(49.9,72.94) ; U2.C5 v2(55.25,53.9)
  INNER1 w0.102: 49.15,70.49 49.15,71.19 49.51,71.55 49.51,72.56 v2(49.9,72.94) ; 54.52,56.41 54.53,56.41 54.53,55.48 54.87,55.14 54.87,54.28 v2(55.25,53.9)
  INNER1 w0.127: 49.15,70.49 49.15,70.1 49.61,69.65 50.22,69.65 50.5,69.37 50.5,63.15 51.85,61.8 54.05,61.8 54.52,61.32 54.52,56.41
DATA1.CLKA: length 156.1
  TOP w0.102: U1.K5 v2(50.9,80.94)
  TOP w0.2: v1(82.73,29.66) 82.73,28.73 83.91,28.73 84.57,28.07 84.57,13.26 ; 84.57,13.26 85.3,12.53 85.3,1.9 84.25,0.85 81.15,0.85 80.17,1.83 U38.11 ; 84.57,13.26 82.73,13.26
  INNER1 w0.102: v2(50.9,80.94) 51.28,80.56 51.74,80.56 51.74,80.56 53.06,80.56 53.06,80.56 55.24,80.56 55.42,80.75 55.59,80.75
  INNER1 w0.2: v1(82.73,29.66) 89.02,29.66 90.25,30.89 101.8,30.89 104.25,33.35 104.25,36.04 103.66,36.64 103.66,45.59 101.3,47.95 101.3,57.21 102.25,58.16 102.25,67.93 97.53,72.65 75.54,72.65 71.7,76.48 71.7,77.05 69.75,79 63.5,79 63.45,78.94 62.95,78.94 62.9,79 62.09,79.81 60.74,79.81 59.8,80.75 55.59,80.75
DATA1.VD0: length 86.6
  TOP w0.102: U1.M2 v2(53.9,82.94)
  INNER1 w0.102: 55.59,83.44 54.4,83.44 v2(53.9,82.94)
  INNER1 w0.2: v1(105.2,44.34) 105.2,45.79 102.9,48.09 102.9,50.09 103.45,50.65 103.45,68.48 98.09,73.84 76.04,73.84 72.9,76.98 72.9,81.36 70.97,83.29 55.9,83.29 55.75,83.44 55.59,83.44
  BOTTOM w0.2: RN3.1 104.25,43.18 104.25,44.15 104.45,44.34 v1(105.2,44.34)
DATA1.VD1: length 85.6
  TOP w0.102: U1.M1 v2(54.9,82.94)
  INNER1 w0.102: 55.59,82.9 54.95,82.9 v2(54.9,82.94)
  INNER1 w0.2: 55.59,82.9 70.8,82.9 72.5,81.19 72.5,76.81 75.87,73.44 97.87,73.44 103.05,68.26 103.05,57.82 102.1,56.87 102.1,48.28 104.59,45.78 104.59,44.06 105.16,43.5 105.24,43.5 v1(105.4,43.34)
  BOTTOM w0.2: v1(105.4,43.34) 104.8,42.74 RN3.2
DATA1.VD2: length 89.3
  TOP w0.102: U1.N3 v2(52.9,83.94)
  INNER1 w0.102: 55.59,82.5 55.54,82.54 53.55,82.54 53.35,82.75 53.35,83.5 v2(52.9,83.94)
  INNER1 w0.2: v1(105.69,42.55) 105.35,42.55 105.16,42.74 105.15,42.74 104.79,43.09 104.79,43.1 104.19,43.7 104.19,45.62 101.7,48.11 101.7,57.05 102.65,58 102.65,68.09 97.7,73.04 75.7,73.04 72.1,76.65 72.1,81.03 70.63,82.5 55.59,82.5
  BOTTOM w0.2: RN3.3 105.48,42.34 v1(105.69,42.55)
DATA1.VD3: length 89.6
  TOP w0.102: U1.N1 v2(54.9,83.94)
  INNER1 w0.102: 55.59,83.94 v2(54.9,83.94)
  INNER1 w0.2: v1(105.1,41.34) 106.25,41.34 106.85,41.95 106.85,42.96 105.85,43.96 105.85,48.65 103.85,50.65 103.85,68.65 98.25,74.25 76.2,74.25 73.3,77.15 73.3,81.53 71.13,83.69 56.2,83.69 55.95,83.94 55.59,83.94
  BOTTOM w0.2: RN3.4 104.5,41.95 v1(105.1,41.34)
DATA1.VD4: length 93.9
  TOP w0.102: U1.P2 v2(53.9,84.94)
  INNER1 w0.102: 55.59,84.46 55.55,84.5 54.35,84.5 v2(53.9,84.94)
  INNER1 w0.2: v1(105.28,38.48) 105.28,38.73 107.25,40.7 107.25,43.13 106.25,44.13 106.25,48.81 104.25,50.81 104.25,68.81 98.42,74.65 76.37,74.65 73.7,77.31 73.7,81.69 71.3,84.09 56.48,84.09 56.12,84.46 55.59,84.46
  BOTTOM w0.2: RN2.1 104.46,38.06 104.84,38.45 105.25,38.45 v1(105.28,38.48)
DATA1.VD5: length 94.4
  TOP w0.102: U1.P1 v2(54.9,84.94)
  INNER1 w0.102: 55.59,84.94 v2(54.9,84.94)
  INNER1 w0.2: 55.59,84.94 56.2,84.94 56.65,84.5 71.5,84.5 74.1,81.9 74.1,77.48 76.53,75.04 98.58,75.04 104.65,68.98 104.65,50.98 106.65,48.98 106.65,44.34 107.65,43.34 107.65,40.53 106,38.88 v1(106,38.08)
  BOTTOM w0.15: v1(106,38.08) 105.67,37.74 104.8,37.74 104.72,37.66 RN2.2
DATA1.VD6: length 98.7
  TOP w0.102: U1.R2 v2(53.9,85.94)
  INNER1 w0.102: 55.59,86.4 54.35,86.4 v2(53.9,85.94)
  INNER1 w0.2: 55.59,86.4 55.95,86.4 57.05,85.29 71.9,85.29 74.9,82.29 74.9,77.84 76.9,75.84 98.95,75.84 105.45,69.34 105.45,51.34 107.5,49.3 107.5,44.66 108.45,43.71 108.45,38.87 v1(107.32,37.74)
  BOTTOM w0.2: RN2.3 104.85,37.27 104.96,37.37 106.94,37.37 v1(107.32,37.74)
DATA1.VD7: length 96.6
  TOP w0.102: U1.R1 v2(54.9,85.94)
  INNER1 w0.102: 55.59,85.94 v2(54.9,85.94)
  INNER1 w0.2: 55.59,85.94 55.83,85.94 56.88,84.9 71.7,84.9 74.5,82.09 74.5,77.65 76.7,75.44 98.75,75.44 105.05,69.15 105.05,51.15 107.05,49.15 107.05,44.55 108.05,43.55 108.05,40.34 106.72,39.01 106.72,37.63 105.83,36.74 v1(105.3,36.74)
  BOTTOM w0.2: v1(105.3,36.74) 105.18,36.87 RN2.4
DATA1.WSTAT_L: length 99.2
  TOP w0.102: U1.J6 v2(49.9,79.94)
  TOP w0.2: U22.11 103.28,34.13 v1(103.25,34.09)
  INNER1 w0.102: v2(49.9,79.94) 50.55,79.29 55.59,79.29
  INNER1 w0.2: 55.59,79.29 59.15,79.29 60.25,78.19 62.57,78.19 62.62,78.15 63.78,78.15 63.83,78.19 69.42,78.19 70.9,76.72 70.9,76.15 75.21,71.84 97.2,71.84 101.41,67.64 101.41,58.65 100.5,57.75 100.5,47.49 101.83,46.16 102.19,45.81 102.19,45.81 102.85,45.14 102.85,34.49 v1(103.25,34.09)
DATA2+: length 27.3
  TOP w0.102: U1.B5 v2(50.9,71.94) ; U2.D6 v2(56.25,52.9)
  INNER1 w0.102: v2(56.25,52.9) 56.25,53.2 55.64,53.8 55.64,56.29 55.62,56.31 55.62,56.41
  INNER1 w0.127: v2(50.9,71.94) 50.9,71.5 50.74,71.34 50.74,71.34 50.51,71.11 50.51,71.1 50.45,71.04 50.45,70.79 50.69,70.55 51.23,70.55 52.6,69.19 52.6,67.46 53.15,67.46 53.15,67.13 52.6,67.13 52.6,66.29 53.15,66.29 53.15,65.97 52.6,65.97 52.6,65.13 53.15,65.13 53.15,64.81 52.6,64.81 52.6,63.55 53.15,62.99 54.23,62.99 55.43,61.8 55.43,59.61 55.62,59.42 55.62,56.41
DATA2-: length 24.8
  TOP w0.102: U1.A5 v2(50.9,70.94) ; U2.C6 v2(56.25,53.9)
  INNER1 w0.102: v2(56.25,53.9) 56.25,53.9 55.87,54.28 55.87,56.4 55.88,56.41
  INNER1 w0.127: 55.88,56.41 55.88,59.57 55.69,59.76 55.69,61.9 54.34,63.25 53.26,63.25 52.85,63.65 52.85,64.55 53.4,64.55 53.4,65.39 52.85,65.39 52.85,65.71 53.4,65.71 53.4,66.55 52.85,66.55 52.85,66.88 53.4,66.88 53.4,67.71 52.85,67.71 52.85,69.29 51.2,70.94 v2(50.9,70.94)
DATA3+: length 27
  TOP w0.102: U2.B6 v2(56.25,54.9) ; U1.D5 v2(50.9,73.94)
  INNER1 w0.102: 56.68,56.11 56.68,55.78 56.25,55.34 v2(56.25,54.9) ; 53.22,70.66 53.2,70.68 53.19,70.68 52.3,71.56 51.74,71.56 51.52,71.79 51.52,72.93 50.9,73.54 v2(50.9,73.94)
  INNER1 w0.127: 53.22,70.66 54,69.88 54,64.5 54.65,63.85 55.3,64.5 55.89,63.9 55.25,63.26 55.48,63.02 56.12,63.67 56.72,63.08 56.07,62.43 56.5,62 56.5,56.29 56.68,56.11
DATA3-: length 24.7
  TOP w0.102: U2.A6 v2(56.25,55.9) ; U1.C5 v2(50.9,72.94)
  INNER1 w0.102: 56.25,56.41 56.25,56.41 v2(56.25,55.9) ; 53.04,70.49 53.02,70.5 53.02,70.52 52.21,71.34 51.65,71.34 51.29,71.69 51.29,72.56 v2(50.9,72.94)
  INNER1 w0.127: 56.25,56.41 56.25,57.54 56.25,57.55 56.25,61.9 55.71,62.43 56.36,63.08 56.12,63.31 55.48,62.66 54.89,63.26 55.53,63.9 55.3,64.14 54.65,63.49 53.75,64.4 53.75,69.78 53.04,70.49
DATA.BA0: length 66
  TOP w0.102: U1.H16 v2(38.9,77.94)
  TOP w0.2: U9.13 17.89,51.84 v1(16.6,51.84) ; v1(20.95,83.09) 20.95,83.63 18.98,85.6 U6.13 ; v1(18,75.75) 18.8,75.75 19.1,75.45 19.1,74.59 18.84,74.34 U8.2
  INNER1 w0.102: v2(38.9,77.94) 38.32,77.94
  INNER1 w0.2: v1(18,75.75) 18,76.9 18.84,77.74 38.11,77.74 38.32,77.94
  INNER2 w0.2: v1(18,75.75) 18,81.75 19.35,83.09 v1(20.95,83.09)
  BOTTOM w0.2: v1(18,75.75) 18,58.45 17.3,57.74 17.3,52.55 v1(16.6,51.84)
DATA.BA1: length 63.9
  TOP w0.102: U1.H15 v2(39.9,77.94)
  TOP w0.2: U9.14 19.02,51.32 19.25,51.55 v1(19.35,51.55) ; U8.3 19.04,73.84 v1(20.05,74.84) 20.05,76.58 20.3,76.83 20.3,83.71 18.91,85.1 U6.14
  INNER1 w0.102: v2(39.9,77.94) 39.44,77.94 39.06,77.56 38.5,77.56 38.32,77.38
  INNER1 w0.2: v1(20.05,74.84) 20.1,74.9 20.1,76.65 20.79,77.34 38.28,77.34 38.32,77.38
  BOTTOM w0.2: v1(20.05,74.84) 21.25,73.65 21.25,52.35 20.45,51.55 v1(19.35,51.55)
DATA.BA2: length 66.4
  TOP w0.102: U1.G14 v2(40.9,76.94)
  TOP w0.2: v1(20.6,53.34) 20.05,52.8 20.05,51.25 19.4,50.59 19,50.59 18.72,50.32 U9.16 ; v1(20.05,73.09) 19.29,73.09 19.04,72.84 U8.5 17.17,72.84 17.06,72.73 16.56,72.73 16.1,73.19 16.1,83.94 16.3,84.15 17,84.15 17.01,84.15 18,84.15 U6.16
  INNER1 w0.102: 38.32,76.54 40.03,76.54 40.44,76.94 v2(40.9,76.94)
  INNER1 w0.2: 38.32,76.54 21.56,76.54 21.05,76.03 21.05,74.1 v1(20.05,73.09)
  BOTTOM w0.2: v1(20.05,73.09) 20.85,72.29 20.85,53.59 v1(20.6,53.34)
DATA.BA3: length 63.1
  TOP w0.102: U1.G16 v2(38.9,76.94)
  TOP w0.2: U9.17 17.94,49.8 v1(19.2,49.8) ; v1(19.4,72.34) 18.05,72.34 U8.6 ; U6.17 18.89,83.6 19.9,82.59 19.9,77 v1(19.4,76.5)
  INNER1 w0.102: 38.32,76.94 38.44,76.94 38.45,76.94 v2(38.9,76.94)
  INNER1 w0.2: 38.32,76.94 21.39,76.94 20.65,76.19 20.65,75.1 20.65,75.1 20.65,74.55 19.8,73.7 19.8,73.7 19.45,73.35 19.45,72.39 v1(19.4,72.34)
  BOTTOM w0.2: v1(19.2,49.8) 18.74,50.25 18.74,51.8 19.1,52.15 19.35,52.15 19.99,52.79 19.99,53.64 20.45,54.09 20.45,71.34 19.45,72.34 v1(19.4,72.34) v1(19.4,76.5)
DATA.BD0: length 33.6
  TOP w0.102: U1.F16 v2(38.9,75.94)
  TOP w0.2: U9.2 v1(16.57,57.32)
  INNER1 w0.102: v2(38.9,75.94) 38.65,75.69 38.32,75.69
  INNER1 w0.2: 38.32,75.69 37,75.69 34,72.69 34,70.11 25.14,61.24 22.69,61.24 19.27,57.83 18.71,57.83 18.2,57.32 v1(16.57,57.32)
DATA.BD1: length 33
  TOP w0.102: U1.F15 v2(39.9,75.94)
  TOP w0.2: U9.3 v1(19.12,56.82)
  INNER1 w0.102: 38.32,74.44 38.42,74.54 39.15,74.54 39.4,74.79 39.4,75.44 v2(39.9,75.94)
  INNER1 w0.2: 38.32,74.44 36.92,74.44 34.8,72.33 34.8,69.78 25.47,60.45 23.02,60.45 20.5,57.92 20.5,57.11 20.21,56.82 v1(19.12,56.82)
DATA.BD2: length 35.2
  TOP w0.102: U1.E16 v2(38.9,74.94)
  TOP w0.2: U9.5 17.04,55.82 16.94,55.72 16.44,55.72 16.33,55.82 v1(15.97,55.82)
  INNER1 w0.102: 38.32,74.94 v2(38.9,74.94)
  INNER1 w0.2: 38.32,74.94 36.85,74.94 34.4,72.5 34.4,69.94 25.3,60.84 22.85,60.84 19.43,57.42 18.87,57.42 17.16,55.72 16.44,55.72 16.33,55.82 v1(15.97,55.82)
DATA.BD3: length 33.3
  TOP w0.102: U1.E15 v2(39.9,74.94)
  TOP w0.2: v1(19.15,55.45) 19.02,55.32 U9.6
  INNER1 w0.102: 38.32,74.04 38.46,74.04 38.74,74.33 39.28,74.33 v2(39.9,74.94)
  INNER1 w0.2: v1(19.15,55.45) 20.25,55.45 20.9,56.09 20.9,57.76 23.19,60.05 25.64,60.05 35.2,69.61 35.2,72.16 37.08,74.04 38.32,74.04
DATA.BD4: length 40.7
  TOP w0.102: U1.E13 v2(41.9,74.94)
  TOP w0.2: v1(15.95,54.45) 16.18,54.22 16.94,54.22 17.04,54.32 U9.8
  INNER1 w0.102: v2(41.9,74.94) 41.52,75.33 40.74,75.33 40.35,74.93 40.35,74.55 40.25,74.44 39.66,74.44 39.28,74.07 39.28,73.79 39.06,73.56 38.4,73.56 38.32,73.65
  INNER1 w0.2: 38.32,73.65 37.25,73.65 35.6,72 35.6,69.44 25.8,59.65 23.35,59.65 21.3,57.59 21.3,55.84 20.28,54.83 18.66,54.83 18.05,54.22 16.18,54.22 v1(15.95,54.45)
DATA.BD5: length 37.5
  TOP w0.102: U1.E12 v2(42.9,74.94)
  TOP w0.2: U9.9 v1(19.07,53.82)
  INNER1 w0.102: 38.32,71.5 38.38,71.56 39.06,71.56 39.52,72.03 39.52,72.1 39.74,72.33 40.23,72.33 40.52,72.61 40.52,73.1 40.74,73.33 41.23,73.33 41.52,73.61 41.52,74.1 41.74,74.33 42.28,74.33 v2(42.9,74.94)
  INNER1 w0.2: v1(19.07,53.82) 19.28,54.02 21.25,54.02 22.1,54.88 22.1,57.26 23.68,58.84 26.13,58.84 36.4,69.11 36.4,70.83 37.07,71.5 38.32,71.5
DATA.BD6: length 33.6
  TOP w0.102: U1.B15 v2(39.9,71.94)
  TOP w0.2: U9.11 v1(19.07,52.82)
  INNER1 w0.102: 39.45,71.51 39.53,71.59 39.55,71.59 v2(39.9,71.94)
  INNER1 w0.2: v1(19.07,52.82) 20.12,52.82 20.25,52.7 21.1,52.7 21.55,53.15 21.55,53.65 22.64,54.74 22.64,57.24 23.85,58.45 26.3,58.45 36.8,68.94 36.8,70.31 37,70.51 39.08,70.51 39.45,70.89 39.45,71.51
DATA.BD7: length 36
  TOP w0.102: U1.B16 v2(38.9,71.94)
  TOP w0.2: U9.12 16.97,52.32 16.8,52.49 v1(16.05,52.49)
  INNER1 w0.102: 38.35,71.9 38.4,71.94 v2(38.9,71.94)
  INNER1 w0.2: 38.35,71.9 36.9,71.9 36,71 36,69.28 25.97,59.24 23.52,59.24 21.7,57.43 21.7,55.05 21.08,54.42 18.82,54.42 16.89,52.49 v1(16.05,52.49)
DATA.BD8: length 64.6
  TOP w0.102: U1.F12 v2(42.9,75.94)
  TOP w0.2: U6.2 18.04,91.09 16.7,91.09 14.5,88.9 14.5,79.4 14.04,78.95 14.04,77.65 v1(14.25,77.44) 13.8,77 13.8,65.58 13.85,65.53 13.85,65.44 15.46,63.84 U8.23
  INNER1 w0.102: 38.32,78.75 40.64,78.75 42.9,76.49 v2(42.9,75.94)
  INNER1 w0.2: v1(14.25,77.44) 16.69,77.44 17.99,78.75 38.32,78.75
DATA.BD9: length 62.9
  TOP w0.102: U1.G11 v2(43.9,76.94)
  TOP w0.2: U8.22 15.61,64.34 14.2,65.74 14.2,76.19 14.44,76.44 14.44,76.45 14.9,76.9 14.9,78.44 v1(14.65,78.69) 14.9,78.94 14.9,88.6 16.14,89.84 16.15,89.84 16.9,90.59 18.04,90.59 U6.3
  INNER1 w0.102: v2(43.9,76.94) 42.7,76.94 40.5,79.15 38.32,79.15
  INNER1 w0.2: 38.32,79.15 17.82,79.15 17.32,78.64 14.7,78.64 v1(14.65,78.69)
DATA.BD12: length 56.3
  TOP w0.102: U1.F13 v2(41.9,75.94)
  TOP w0.2: U6.8 16.6,88.1 15.3,86.8 15.3,76.44 v1(15.05,76.19) 14.65,75.79 14.65,67.94 15.76,66.83 17.23,66.83 17.24,66.84 U8.17
  INNER1 w0.102: v2(41.9,75.94) 41.9,76.41 41.52,76.79 41.52,77.19 40.22,78.5 38.47,78.5 38.32,78.34
  INNER1 w0.2: v1(15.05,76.19) 16,76.19 18.15,78.34 38.32,78.34
DATA.BD13: length 55.4
  TOP w0.102: U1.F14 v2(40.9,75.94)
  TOP w0.2: U8.16 17.17,67.34 17.06,67.23 16.01,67.23 15.45,67.79 v1(15.45,70) 15.45,71.15 15.7,71.4 15.7,86.6 16.7,87.6 U6.9
  INNER1 w0.102: 38.32,76.14 38.48,76.14 38.67,76.33 40.06,76.33 40.44,75.94 v2(40.9,75.94)
  INNER1 w0.2: 38.32,76.14 22.04,76.14 21.49,75.59 21.49,73.59 19.9,72 19.9,71.11 19.9,71.11 19.9,71.09 19.54,70.73 19.52,70.73 18.48,69.69 15.75,69.69 v1(15.45,70)
DATA.BD14: length 45
  TOP w0.102: U1.C15 v2(39.9,72.94)
  TOP w0.2: U6.11 19.14,86.6 21.95,83.79 21.95,72.44 23,71.4 23,70.29 v1(22.45,69.75) 21.04,68.34 U8.14
  INNER2 w0.102: 38.7,72.49 38.99,72.49 39.44,72.94 v2(39.9,72.94)
  INNER2 w0.2: v1(22.45,69.75) 23.1,70.4 23.1,70.79 23.8,71.5 25.74,71.5 27.34,73.09 38.15,73.09 38.5,72.74 38.5,72.69 38.7,72.49
DATA.BD15: length 41.6
  TOP w0.102: U1.C16 v2(38.9,72.94)
  TOP w0.2: U6.12 19.04,86.1 21.55,83.59 21.55,72.15 22.25,71.45 v1(22.25,70.59) 20.49,68.84 U8.13
  INNER2 w0.2: v1(22.25,70.59) 23.55,71.9 25.57,71.9 27.18,73.5 27.51,73.5 27.51,73.5 38.35,73.5 v2(38.9,72.94)
DATA.CLKB: length 41.5
  TOP w0.1: 38.32,79.44 U1.J16
  TOP w0.2: 38.32,79.44 37.75,79.44 v1(33.75,75.44)
  INNER1 w0.2: J6.E16 9.67,66.81 10.02,67.16 10.02,67.17 10.51,67.66 10.52,67.66 12.1,69.25 18.6,69.25 19.69,70.33 19.71,70.33 20.3,70.92 20.3,70.94 20.3,70.94 20.3,71.84 21.89,73.43 21.89,75.19 22.4,75.69 33.5,75.69 v1(33.75,75.44)
DDIR: length 63.7
  TOP w0.2: U6.1 18.78,91.6 18.78,91.59 19.1,91.59 v1(19.4,91.29) ; U9.1 18.88,57.82 19.25,58.2 v1(19.25,63.3) 18.09,63.3 U8.24 ; U7.1 v1(18.02,39.62)
  BOTTOM w0.2: v1(18.02,39.62) 17.7,39.95 17.7,57.45 19.25,58.99 v1(19.25,63.3) 18.65,63.89 18.65,64.17 18.65,64.17 18.65,90.55 v1(19.4,91.29)
DDR_A0: length 37.7
  TOP w0.102: U2.C1 50.9,54.24 44.65,54.24 43.1,52.7 34.8,52.7 33.85,53.65 33.85,54.59 v2(34.3,55.05) U12.M8 ; U13.M8 v2(34.3,41.24)
  INNER2 w0.102: v2(34.3,55.05) 34.1,54.85 34.1,54.72 33.5,54.12 33.5,48.59 34.85,47.24 35.24,47.24 35.48,47 35.48,42.88 35,42.4 35,41.95 v2(34.3,41.24)
DDR_A1: length 38.3
  TOP w0.102: U13.M3 v2(34.3,46.05) ; U2.D1 v2(51.25,52.9) ; U12.M3 v2(34.3,59.84)
  INNER1 w0.102: v2(34.3,46.05) 33.88,46.46 33.88,59.43 v2(34.3,59.84)
  INNER2 w0.102: v2(34.3,59.84) 34.3,58.49 35.55,57.24 37.25,57.24 37.9,56.59 37.9,53.74 38.75,52.9 v2(51.25,52.9)
DDR_A2: length 35.8
  TOP w0.102: U2.E1 v2(51.25,51.9) ; U13.M7 34.3,42.84 v2(34.3,43.34) ; v2(34.3,55.84) U12.M7 35.2,56.74 v2(36.7,56.74)
  INNER2 w0.102: v2(51.25,51.9) 50.43,52.71 38.67,52.71 37.72,53.67 37.72,56.03 37,56.74 v2(36.7,56.74) ; v2(34.3,43.34) 33.92,43.73 33.92,47.88 33.3,48.49 33.3,54.18 33.92,54.8 33.92,55.2 34.3,55.58 v2(34.3,55.84)
DDR_A3: length 39.3
  TOP w0.102: U2.F1 51.75,50 52.11,49.64 52.11,49.2 51.75,48.84 33.8,48.84 33.1,48.15 33.1,47.24 v2(33.5,46.84) U13.N2 ; U12.N2 v2(33.5,60.65)
  BOTTOM w0.102: v2(33.5,46.84) 33.1,47.24 33.1,48.05 33.34,48.29 33.34,54.66 33.1,54.91 33.1,56.15 33.5,56.55 34.5,56.55 34.75,56.8 34.75,58.84 33.88,59.71 33.88,60.26 v2(33.5,60.65)
DDR_A4: length 36.8
  TOP w0.102: U12.N8 v2(33.5,55.05) 33.5,53.4 34.45,52.45 42.4,52.45 44.95,49.9 50,49.9 50.5,49.4 U2.G1 ; U13.N8 v2(33.5,41.24)
  BOTTOM w0.102: v2(33.5,41.24) 33.5,43.45 33.9,43.84 33.9,54.65 v2(33.5,55.05)
DDR_A5: length 34.5
  TOP w0.102: U12.N3 v2(33.5,59.84) ; v2(33.5,46.05) U13.N3 34.26,45.29 44.99,45.29 46.65,46.95 49.6,46.95 51.05,48.4 U2.H1
  INNER1 w0.102: v2(33.5,59.84) 33.12,59.46 33.12,46.43 v2(33.5,46.05)
DDR_A6: length 34.8
  TOP w0.102: U13.N7 33.5,42.84 v2(33.5,43.99) 33.9,44.4 45.5,44.4 46.15,45.05 49.6,45.05 50.05,45.49 50.05,46.74 50.7,47.4 U2.J1 ; U12.N7 v2(33.5,55.84)
  INNER2 w0.102: v2(33.5,43.99) 33.5,45.51 33.12,45.89 33.12,55.2 33.5,55.58 v2(33.5,55.84)
DDR_A7: length 44.5
  TOP w0.102: U12.P2 v2(32.7,60.65) ; U2.K1 v2(51.25,45.9) ; U13.P2 v2(32.7,46.84)
  INNER2 w0.1: 37.5,53.55 38.55,52.49 50.1,52.49 51.45,51.15 51.45,48.4 51.25,48.2 v2(51.25,45.9)
  INNER2 w0.102: v2(34.3,57.4) 35.4,56.3 37.1,56.3 37.5,55.9 37.5,53.55
  BOTTOM w0.102: v2(32.7,60.65) 33.08,60.26 33.08,59.36 34.3,58.15 v2(34.3,57.4) 34.3,56.95 34.1,56.74 32.8,56.74 32.25,56.2 32.25,48.2 32.7,47.74 v2(32.7,46.84)
DDR_A8: length 37.1
  TOP w0.102: U12.P8 v2(32.7,55.05) ; v2(32.7,41.24) U13.P8 33.5,42.05 34.85,42.05 35.1,42.3 35.1,43.05 34.7,43.45 34.7,43.9 34.95,44.15 49.65,44.15 50.9,45.4 U2.L1
  BOTTOM w0.102: v2(32.7,41.24) 32.75,41.24 33.1,41.59 33.1,46.99 32.92,47.17 32.92,48.12 33.1,48.3 33.1,54.65 v2(32.7,55.05)
DDR_A9: length 34.9
  TOP w0.102: U2.M1 v2(51.25,43.9) ; v2(32.7,46.05) U13.P3 33.85,44.9 39.05,44.9 39.15,44.8 v2(44.55,44.8) ; U12.P3 v2(32.7,59.84)
  INNER1 w0.102: v2(32.7,59.84) 32.32,59.46 32.32,46.43 v2(32.7,46.05)
  INNER2 w0.102: v2(51.25,43.9) 51.15,43.99 45.3,43.99 44.55,44.74 v2(44.55,44.8)
DDR_A10: length 36.7
  TOP w0.102: U2.N1 51.7,43.4 50.52,42.21 46.33,42.21 44.85,43.7 v2(35.1,43.7) ; U12.M2 v2(34.3,60.65) ; U13.M2 v2(34.3,46.84)
  INNER1 w0.102: v2(35.1,43.7) 34.68,44.11 34.68,46.2 34.3,46.58 v2(34.3,46.84)
  BOTTOM w0.102: v2(34.3,60.65) U12.M2 34.7,59.24 35,58.95 35,56.55 34.7,56.24 34.7,48.15 34.52,47.97 34.52,47.06 v2(34.3,46.84)
DDR_A11: length 38.7
  TOP w0.102: U13.P7 32.7,42.84 v2(32.7,42.9) ; U12.P7 v2(32.7,55.84) ; U2.P1 v2(51.25,41.9)
  INNER2 w0.102: v2(32.7,55.84) 32.7,55.58 32.32,55.2 32.32,54.05 32.94,53.43 32.94,47.63 32.32,47.01 32.32,45.89 32.7,45.51 v2(32.7,42.9)
  BOTTOM w0.102: v2(32.7,42.9) 32.7,41.78 32.32,41.4 32.32,41.09 32.54,40.86 32.88,40.86 33.1,40.65 33.1,40.3 33.33,40.06 35.13,40.06 35.61,39.58 49.45,39.58 50.87,41 50.87,41.05 51.25,41.43 v2(51.25,41.9)
DDR_A12: length 43
  TOP w0.102: U2.R1 v2(51.25,40.9) ; U12.R2 v2(31.9,60.65) ; U13.R2 v2(31.9,46.84)
  INNER2 w0.1: v2(31.9,60.65) 32.14,60.41 32.14,53.97 32.75,53.36 32.75,47.74 31.9,46.9 v2(31.9,46.84)
  BOTTOM w0.102: v2(31.9,46.84) 32.1,46.65 32.1,40.51 32.72,39.88 35.05,39.88 35.54,39.4 49.53,39.4 51.02,40.9 v2(51.25,40.9)
DDR_BA0: length 34.6
  TOP w0.102: U13.L1 v2(35.1,47.65) ; U12.L2 v2(35.1,60.65) ; U2.M2 v2(52.25,43.9)
  INNER2 w0.1: 51.4,44.28 51.41,44.27 51.79,43.9 v2(52.25,43.9)
  INNER2 w0.102: 51.4,44.28 51.09,44.28 51.03,44.21 45.73,44.21 v2(45.15,44.8)
  BOTTOM w0.102: v2(35.1,60.65) U12.L2 35.5,59.59 36.28,58.81 36.28,53.38 35.1,52.2 v2(35.1,47.65) 36.3,46.45 38.8,46.45 39.95,45.3 44.65,45.3 v2(45.15,44.8)
DDR_BA1: length 41.1
  TOP w0.102: U13.L3 v2(35.1,46.05) ; U12.L3 v2(35.1,59.84) ; U2.P2 v2(52.25,41.9)
  INNER1 w0.102: v2(35.1,59.84) 34.68,59.43 34.68,46.46 v2(35.1,46.05)
  BOTTOM w0.102: v2(52.25,41.9) 52.25,42.34 51.85,42.74 51.85,43.05 51.62,43.28 50.58,43.28 50.32,43.01 50.32,41.27 49.91,40.86 48.79,40.86 48.75,40.9 48.05,40.9 48.01,40.86 47.79,40.86 47.75,40.9 47.05,40.9 47.01,40.86 35.62,40.86 35.5,40.98 35.5,43.84 35.1,44.24 v2(35.1,46.05)
DDR_BA2: length 58.7
  TOP w0.102: U13.L2 v2(35.1,46.84) ; U12.L1 v2(35.1,61.45) ; U2.R2 v2(52.25,40.9)
  INNER2 w0.102: v2(35.1,61.45) 34.68,61.03 31.73,61.03 31.52,60.81 31.52,60.49 31.96,60.05 31.96,53.9 32.57,53.28 32.57,47.82 32.04,47.3 31.8,47.3 31.35,46.84 31.25,46.84 31.25,43.67 32.42,42.49 34.1,42.49 34.7,43.09 34.7,46.45 v2(35.1,46.84)
  BOTTOM w0.102: v2(52.25,40.9) 52.15,40.9 51.63,41.41 51.63,42.05 51.41,42.28 51.09,42.28 50.69,41.87 50.69,41.07 49.38,39.76 35.72,39.76 34.72,40.77 34.72,46.46 v2(35.1,46.84)
DDR_DQ0: length 20.1
  TOP w0.102: U2.F5 v2(55.25,50.9) ; U12.G8 v2(39.1,55.05)
  INNER1 w0.1: v2(39.1,55.05) 39.5,54.65 40.05,54.65 40.3,54.39 40.3,54.1 43.66,50.74 46.25,50.74 46.42,50.91 46.88,50.91 47.05,50.74 48.75,50.74 48.92,50.91 49.79,50.91 50.42,50.28 54.63,50.28 v2(55.25,50.9)
DDR_DQ1: length 19.8
  TOP w0.102: U12.G2 v2(39.1,60.65) ; U2.C2 v2(52.25,53.9)
  INNER1 w0.1: v2(52.25,53.9) 51.87,54.28 51.41,54.28 51.31,54.18 51.31,53.78 51.21,53.68 51.01,53.68 50.91,53.78 50.91,54.18 50.81,54.28 50.48,54.28 49.91,54.84 49.91,55.15 48.45,56.61 40.63,56.61 39.1,58.14 v2(39.1,60.65)
DDR_DQ2: length 21.6
  TOP w0.102: U2.F4 v2(54.25,50.9) ; U12.H7 v2(38.3,55.84)
  INNER1 w0.1: v2(38.3,55.84) 38.68,55.46 40.38,55.46 41.1,54.74 41.1,53.56 43.72,50.95 45.71,50.95 46.49,51.73 46.81,51.73 47.52,51.01 48.28,51.01 48.99,51.73 49.31,51.73 50.58,50.46 53.81,50.46 v2(54.25,50.9)
DDR_DQ3: length 22.3
  TOP w0.102: U12.H3 v2(38.3,59.84) ; U2.E4 v2(54.25,51.9)
  INNER1 w0.1: v2(54.25,51.9) 53.75,52.4 53.15,52.4 52.85,52.7 52.85,52.83 52.41,53.28 50.12,53.28 49.55,53.84 49.55,54.99 48.3,56.24 40.2,56.24 38.3,58.15 v2(38.3,59.84)
DDR_DQ4: length 22.1
  TOP w0.102: U12.H1 v2(38.3,61.45) ; U2.D3 v2(53.25,52.9)
  INNER1 w0.1: v2(53.25,52.9) 52.69,53.46 50.29,53.46 49.73,54.02 49.73,55.07 48.38,56.43 40.42,56.43 38.68,58.16 38.68,61.06 v2(38.3,61.45)
DDR_DQ5: length 20.8
  TOP w0.102: U12.H9 v2(38.3,54.24) ; U2.G5 v2(55.25,49.9)
  INNER1 w0.1: v2(38.3,54.24) 38.86,53.68 40.06,53.68 44,49.74 46.25,49.74 46.42,49.91 46.88,49.91 47.05,49.74 48.75,49.74 48.92,49.91 49.38,49.91 50.02,49.28 54.63,49.28 v2(55.25,49.9)
DDR_DQ6: length 20.3
  TOP w0.102: U2.C3 v2(53.25,53.9) ; U12.F1 v2(39.9,61.45)
  INNER1 w0.1: v2(53.25,53.9) 52.67,54.47 50.84,54.47 48.53,56.79 40.85,56.79 39.48,58.16 39.48,61.03 v2(39.9,61.45)
DDR_DQ7: length 19.8
  TOP w0.102: U12.F9 v2(39.9,54.24) ; U2.G3 v2(53.25,49.9)
  INNER1 w0.1: v2(53.25,49.9) 52.81,49.46 51.6,49.46 51.5,49.56 51.5,49.96 51.4,50.06 51.2,50.06 51.1,49.96 51.1,49.56 51,49.46 50.58,49.46 49.31,50.73 48.99,50.73 48.29,50.03 47.51,50.03 46.81,50.73 46.49,50.73 45.71,49.94 45.21,49.94 45.11,50.04 45.11,50.34 45.01,50.44 44.81,50.44 44.71,50.34 44.71,50.04 44.61,49.94 44.1,49.94 39.9,54.15 v2(39.9,54.24)
DDR_DQ8: length 19.9
  TOP w0.102: U2.E2 v2(52.25,51.9) ; U12.C8 v2(42.3,55.05)
  INNER1 w0.1: v2(52.25,51.9) 51.87,52.28 50.46,52.28 50.36,52.38 50.36,52.78 50.26,52.88 50.06,52.88 49.96,52.78 49.96,52.38 49.86,52.28 49.46,52.28 49.27,52.46 49.27,52.6 49.42,52.74 49.42,52.88 49.27,53.02 49.13,53.02 48.99,52.88 48.85,52.88 48.57,53.17 48.1,53.17 48,53.27 48,54.07 47.9,54.17 47.7,54.17 47.6,54.07 47.6,53.27 47.5,53.17 45.97,53.17 45.87,53.27 45.87,54.07 45.77,54.17 45.57,54.17 45.47,54.07 45.47,53.27 45.37,53.17 45.17,53.17 45.07,53.27 45.07,54.07 44.97,54.17 44.77,54.17 44.67,54.07 44.67,53.27 44.57,53.17 43.25,53.17 42.7,53.72 42.7,54.65 v2(42.3,55.05)
DDR_DQ9: length 20.4
  TOP w0.102: U2.B3 v2(53.25,54.9) ; U12.C2 v2(42.3,60.65)
  INNER1 w0.1: v2(42.3,60.65) 42.68,60.26 42.68,59.5 43.22,58.96 43.36,58.96 43.5,59.1 43.64,59.1 43.78,58.96 43.78,58.82 43.64,58.68 43.64,58.54 43.78,58.39 43.92,58.39 44.07,58.54 44.2,58.54 44.35,58.39 44.35,58.25 44.21,58.11 44.21,57.97 44.44,57.73 44.91,57.73 45.01,57.84 45.01,58.13 45.11,58.23 45.31,58.23 45.41,58.13 45.41,57.84 45.51,57.73 45.71,57.73 45.81,57.84 45.81,58.13 45.91,58.23 46.11,58.23 46.21,58.13 46.21,57.84 46.31,57.73 46.51,57.73 46.61,57.84 46.61,58.13 46.71,58.23 46.91,58.23 47.01,58.13 47.01,57.84 47.11,57.73 47.31,57.73 47.41,57.84 47.41,58.13 47.51,58.23 47.71,58.23 47.81,58.13 47.81,57.84 47.91,57.73 48.4,57.73 48.73,57.4 49.11,57.4 49.39,57.12 49.53,57.12 49.67,57.26 49.81,57.26 49.96,57.12 49.96,56.98 49.81,56.84 49.81,56.7 49.96,56.55 50.1,56.55 50.24,56.7 50.38,56.7 50.52,56.55 50.52,56.41 50.38,56.27 50.38,56.13 51.02,55.49 52.65,55.49 v2(53.25,54.9)
DDR_DQ10: length 19.8
  TOP w0.102: U2.F3 v2(53.25,50.9) ; U12.D7 v2(41.5,55.84)
  INNER1 w0.1: v2(53.25,50.9) 52.67,51.48 50.67,51.48 50.06,52.09 49.39,52.09 48.89,52.59 48.31,52.59 48.21,52.69 48.21,52.89 48.11,52.99 47.91,52.99 47.81,52.89 47.81,52.69 47.71,52.59 47.51,52.59 47.41,52.69 47.41,52.89 47.31,52.99 47.11,52.99 47.01,52.89 47.01,52.69 46.91,52.59 46.71,52.59 46.61,52.69 46.61,52.89 46.51,52.99 46.31,52.99 46.21,52.89 46.21,52.69 46.11,52.59 45.91,52.59 45.81,52.69 45.81,52.89 45.71,52.99 45.51,52.99 45.41,52.89 45.41,52.69 45.31,52.59 45.11,52.59 45.01,52.69 45.01,52.89 44.91,52.99 44.71,52.99 44.61,52.89 44.61,52.69 44.51,52.59 44.31,52.59 44.21,52.69 44.21,52.89 44.11,52.99 43.91,52.99 43.81,52.89 43.81,52.69 43.71,52.59 43.15,52.59 42.87,52.87 42.87,53.01 42.94,53.08 42.94,53.22 42.8,53.37 42.66,53.37 42.59,53.29 42.45,53.29 41.88,53.86 41.88,55.2 41.5,55.58 v2(41.5,55.84)
DDR_DQ11: length 19.7
  TOP w0.102: U12.D3 v2(41.5,59.84) ; U2.B1 v2(51.25,54.9)
  INNER1 w0.1: v2(41.5,59.84) 41.5,58.98 41.64,58.83 41.64,58.7 40.61,57.66 40.61,57.52 40.76,57.38 40.89,57.38 41.93,58.41 42.06,58.41 42.21,58.27 42.21,58.13 41.44,57.36 41.44,57.22 41.58,57.08 41.72,57.08 42.49,57.85 42.63,57.85 42.78,57.7 42.78,57.56 42.57,57.36 42.57,57.22 42.72,57.08 42.85,57.08 43.06,57.28 43.2,57.28 43.5,56.97 48.6,56.97 50.68,54.9 v2(51.25,54.9)
DDR_DQ12: length 20.7
  TOP w0.102: U12.D1 v2(41.5,61.45) ; U2.B2 v2(52.25,54.9)
  INNER1 w0.1: v2(41.5,61.45) 41.88,61.06 41.88,59.41 42.36,58.93 42.5,58.93 42.57,59.01 42.71,59.01 42.86,58.86 42.86,58.72 42.78,58.65 42.78,58.51 42.93,58.37 43.07,58.37 43.14,58.44 43.28,58.44 43.42,58.29 43.42,58.16 43.35,58.08 43.35,57.95 43.49,57.8 43.63,57.8 43.71,57.87 43.84,57.87 43.99,57.73 43.99,57.59 43.92,57.52 43.92,57.38 44.14,57.16 44.5,57.16 44.6,57.26 44.6,57.45 44.7,57.55 44.9,57.55 45,57.45 45,57.26 45.1,57.16 45.3,57.16 45.4,57.26 45.4,57.45 45.5,57.55 45.7,57.55 45.8,57.45 45.8,57.26 45.9,57.16 46.1,57.16 46.2,57.26 46.2,57.45 46.3,57.55 46.5,57.55 46.6,57.45 46.6,57.26 46.7,57.16 46.9,57.16 47,57.26 47,57.45 47.1,57.55 47.3,57.55 47.4,57.45 47.4,57.26 47.5,57.16 47.7,57.16 47.8,57.26 47.8,57.45 47.9,57.55 48.1,57.55 48.2,57.45 48.2,57.26 48.3,57.16 48.68,57.16 48.83,57 48.97,57 49.04,57.08 49.18,57.08 49.33,56.93 49.33,56.79 49.25,56.72 49.25,56.58 49.4,56.44 49.53,56.44 49.61,56.51 49.75,56.51 49.89,56.37 49.89,56.23 49.82,56.16 49.82,56.02 49.96,55.87 50.1,55.87 50.17,55.95 50.31,55.95 50.46,55.8 50.46,55.66 50.38,55.59 50.38,55.45 50.54,55.3 51.85,55.3 v2(52.25,54.9)
DDR_DQ13: length 20.8
  TOP w0.102: U2.F2 v2(52.25,50.9) ; U12.D9 v2(41.5,54.24)
  INNER1 w0.1: v2(52.25,50.9) 51.37,50.9 51.27,50.99 51.27,51.2 51.17,51.3 50.97,51.3 50.87,51.2 50.87,50.99 50.77,50.9 50.4,50.9 50.1,51.19 50.1,51.33 50.24,51.47 50.24,51.61 50.1,51.76 49.96,51.76 49.82,51.61 49.68,51.61 49.38,51.91 48.49,51.91 48.39,52.01 48.39,52.31 48.29,52.41 48.09,52.41 47.99,52.31 47.99,52.01 47.89,51.91 47.69,51.91 47.59,52.01 47.59,52.31 47.49,52.41 47.29,52.41 47.19,52.31 47.19,52.01 47.09,51.91 46.89,51.91 46.79,52.01 46.79,52.31 46.69,52.41 46.49,52.41 46.39,52.31 46.39,52.01 46.29,51.91 46.09,51.91 45.99,52.01 45.99,52.31 45.89,52.41 45.69,52.41 45.59,52.31 45.59,52.01 45.49,51.91 45.29,51.91 45.19,52.01 45.19,52.31 45.09,52.41 44.89,52.41 44.79,52.31 44.79,52.01 44.69,51.91 44.49,51.91 44.39,52.01 44.39,52.31 44.29,52.41 44.09,52.41 43.99,52.31 43.99,52.01 43.89,51.91 43.01,51.91 42.75,52.17 42.75,52.31 42.89,52.45 42.89,52.59 42.74,52.74 42.61,52.74 42.46,52.59 42.33,52.59 42.18,52.74 42.18,52.88 42.32,53.02 42.32,53.16 42.18,53.3 42.04,53.3 41.9,53.16 41.76,53.16 41.5,53.42 v2(41.5,54.24)
DDR_DQ14: length 19.9
  TOP w0.102: U12.B1 v2(43.1,61.45) ; U2.A2 v2(52.25,55.9)
  INNER1 w0.1: v2(43.1,61.45) 43.52,61.03 43.52,60.81 43.62,60.71 44.02,60.71 44.12,60.61 44.12,60.41 44.02,60.31 43.62,60.31 43.52,60.21 43.52,59.63 44.09,59.06 44.23,59.06 44.51,59.34 44.65,59.34 44.8,59.2 44.8,59.06 44.51,58.77 44.51,58.63 44.73,58.41 45.25,58.41 45.35,58.52 45.35,59.02 45.45,59.12 45.65,59.12 45.75,59.02 45.75,58.52 45.85,58.41 46.05,58.41 46.15,58.52 46.15,59.02 46.25,59.12 46.45,59.12 46.55,59.02 46.55,58.52 46.65,58.41 46.85,58.41 46.95,58.52 46.95,59.02 47.05,59.12 47.25,59.12 47.35,59.02 47.35,58.52 47.45,58.41 47.98,58.41 48.19,58.21 48.32,58.21 48.61,58.49 48.75,58.49 48.89,58.35 48.89,58.21 48.61,57.93 48.61,57.79 48.81,57.58 49.75,57.58 51.04,56.3 51.85,56.3 v2(52.25,55.9)
DDR_DQ15: length 20.2
  TOP w0.102: U12.B9 v2(43.1,54.24) ; v2(53.25,51.9) U2.E3
  INNER1 w0.1: v2(43.1,54.24) 43.5,53.85 44.09,53.85 44.59,54.35 44.93,54.35 45.03,54.45 45.03,54.65 44.93,54.75 44.43,54.75 44.33,54.85 44.33,55.05 44.43,55.15 44.93,55.15 45.03,55.25 45.03,55.97 45.13,56.06 45.33,56.06 45.43,55.97 45.43,55.76 45.53,55.66 46.23,55.66 46.33,55.56 46.33,55.36 46.23,55.26 45.53,55.26 45.43,55.16 45.43,54.45 45.53,54.35 45.87,54.35 46.06,54.16 46.06,53.74 46.45,53.35 46.86,53.35 47.42,53.91 47.42,54.19 47.58,54.35 48,54.35 48.18,54.17 48.18,53.89 48.72,53.35 49.39,53.35 49.68,53.06 50.45,53.06 51.04,52.46 52.69,52.46 v2(53.25,51.9)
DDR_DQ16: length 19.7
  TOP w0.102: U2.L3 v2(53.25,44.9) ; U13.G8 v2(39.1,41.24)
  INNER1 w0.1: v2(53.25,44.9) 52.87,45.28 51.09,45.28 50.81,44.99 49,44.99 48.76,44.76 48.55,44.76 48.45,44.66 48.45,44.53 48.35,44.43 48.15,44.43 48.05,44.53 48.05,44.66 47.95,44.76 47.37,44.76 46.78,44.16 46.42,44.16 46.1,43.85 43.77,43.85 43.67,43.75 43.67,43.65 43.57,43.55 43.37,43.55 43.27,43.65 43.27,43.75 43.17,43.85 42.6,43.85 42.29,43.54 42.15,43.54 42.01,43.68 41.87,43.68 41.73,43.53 41.73,43.4 41.97,43.15 41.97,43.01 41.83,42.87 41.69,42.87 41.44,43.11 41.3,43.11 41.16,42.97 41.16,42.83 41.3,42.69 41.3,42.55 41.12,42.37 41.12,41.92 40.83,41.63 39.48,41.63 v2(39.1,41.24)
DDR_DQ17: length 20
  TOP w0.102: U2.H5 v2(55.25,48.9) ; U13.G2 v2(39.1,46.84)
  INNER1 w0.1: v2(55.25,48.9) 54.1,47.75 53.38,47.75 53.28,47.65 50.11,47.65 49.93,47.83 48.6,47.83 48.5,47.93 48.5,48.03 48.4,48.13 48.2,48.13 48.1,48.03 48.1,47.93 48,47.83 47.8,47.83 47.7,47.93 47.7,48.03 47.6,48.13 47.4,48.13 47.3,48.03 47.3,47.93 47.2,47.83 46.47,47.83 46.05,48.25 43.16,48.25 42.72,47.8 42.72,47.52 42.43,47.23 41.34,47.23 40.96,46.84 40.44,46.84 40.06,46.46 39.74,46.46 39.36,46.84 v2(39.1,46.84)
DDR_DQ18: length 19.8
  TOP w0.102: U2.K5 v2(55.25,45.9) ; U13.H7 v2(38.3,42.05)
  INNER1 w0.1: v2(55.25,45.9) 54.87,45.51 50.97,45.51 50.67,45.21 48.92,45.21 48.68,44.98 46.49,44.98 45.61,44.09 41.95,44.09 40.28,42.43 38.68,42.43 v2(38.3,42.05)
DDR_DQ19: length 20.1
  TOP w0.102: U2.K2 v2(52.25,45.9) ; U13.H3 v2(38.3,46.05)
  INNER1 w0.1: v2(52.25,45.9) 51.87,46.28 51.09,46.28 50.7,45.88 50.7,45.72 50.4,45.42 49.88,45.42 49.28,46.02 49.04,46.02 48.21,45.2 46.41,45.2 46.18,44.97 45.86,44.97 45.26,44.37 44.07,44.37 43.97,44.47 43.97,44.56 43.87,44.66 43.67,44.66 43.57,44.56 43.57,44.47 43.47,44.37 42.49,44.37 42.39,44.47 42.39,44.56 42.29,44.66 42.09,44.66 41.99,44.56 41.99,44.47 41.89,44.37 41.69,44.37 41.59,44.47 41.59,44.56 41.49,44.66 41.29,44.66 41.19,44.56 41.19,44.47 41.09,44.37 40.89,44.37 40.79,44.47 40.79,44.56 40.69,44.66 40.49,44.66 40.39,44.56 40.39,44.47 40.29,44.37 40.09,44.37 39.99,44.47 39.99,44.56 39.89,44.66 39.69,44.66 39.59,44.56 39.59,44.47 39.49,44.37 39.28,44.37 39,44.65 39,44.78 39.07,44.86 39.07,44.99 38.93,45.14 38.79,45.14 38.72,45.07 38.58,45.07 38.3,45.34 v2(38.3,46.05)
DDR_DQ20: length 20.1
  TOP w0.102: U13.H1 v2(38.3,47.65) ; U2.H3 v2(53.25,48.9)
  INNER1 w0.1: v2(38.3,47.65) 38.3,48.65 38.5,48.84 39.35,48.84 39.5,48.7 39.5,47.41 39.65,47.26 40.07,47.26 40.32,47.51 40.32,47.8 41.46,48.95 49.35,48.95 49.98,48.31 52.47,48.31 52.77,48.62 52.97,48.62 v2(53.25,48.9)
DDR_DQ21: length 20.2
  TOP w0.102: U13.H9 v2(38.3,40.45) ; U2.L5 v2(55.25,44.9)
  INNER1 w0.1: v2(38.3,40.45) 38.68,40.83 40.28,40.83 41.08,41.63 41.63,41.63 41.92,41.91 41.92,42.2 42.14,42.43 42.68,42.43 43.44,43.18 47.82,43.18 48.64,43.99 50.8,43.99 51.1,44.3 54.65,44.3 v2(55.25,44.9)
DDR_DQ22: length 19.8
  TOP w0.102: v2(52.35,48.84) 52.35,48.8 U2.H2 ; U13.F1 v2(39.9,47.65)
  INNER1 w0.1: v2(52.35,48.84) 52,48.49 51.49,48.49 51.39,48.59 51.39,48.99 51.29,49.09 51.09,49.09 50.99,48.99 50.99,48.59 50.89,48.49 50.54,48.49 49.31,49.73 48.99,49.73 48.44,49.17 48.2,49.17 48.1,49.27 48.1,49.37 48,49.47 47.8,49.47 47.7,49.37 47.7,49.27 47.6,49.17 47.36,49.17 46.81,49.73 46.49,49.73 46.16,49.4 43.3,49.4 43.2,49.5 43.2,49.9 43.1,50 42.9,50 42.8,49.9 42.8,49.5 42.7,49.4 42.5,49.4 42.4,49.5 42.4,49.9 42.3,50 42.1,50 42,49.9 42,49.5 41.9,49.4 41.65,49.4 40.91,48.66 40.78,48.66 40.49,48.95 40.35,48.95 40.21,48.8 40.21,48.66 40.49,48.38 40.49,48.24 v2(39.9,47.65)
DDR_DQ23: length 19.8
  TOP w0.102: U2.M4 v2(54.25,43.9) ; U13.F9 v2(39.9,40.45)
  INNER1 w0.1: v2(39.9,40.45) 40.16,40.45 40.58,40.86 41.66,40.86 41.92,41.12 41.92,41.4 42.18,41.66 42.46,41.66 42.72,41.92 42.72,42.2 43.51,42.99 43.74,42.99 43.84,42.9 43.84,42.76 43.94,42.66 44.14,42.66 44.24,42.76 44.24,42.9 44.34,42.99 47.9,42.99 48.12,43.21 49.85,43.21 49.95,43.31 49.95,43.71 50.05,43.81 50.25,43.81 50.35,43.71 50.35,43.31 50.45,43.21 50.77,43.21 51.02,43.46 52.89,43.46 52.99,43.56 52.99,43.96 53.09,44.06 53.29,44.06 53.39,43.96 53.39,43.56 53.49,43.46 53.81,43.46 v2(54.25,43.9)
DDR_DQ24: length 19.7
  TOP w0.102: U2.M5 v2(55.25,43.9) ; U13.C8 v2(42.3,41.24)
  INNER1 w0.1: v2(55.25,43.9) 54.63,43.28 51.87,43.28 51.57,42.98 51.1,42.98 51,42.88 51,42.78 50.91,42.68 50.7,42.68 50.6,42.78 50.6,42.88 50.5,42.98 48.73,42.98 48.49,42.73 48.49,42.59 48.67,42.41 48.67,42.27 48.52,42.13 48.38,42.13 48.2,42.31 48.06,42.31 47.9,42.15 47.64,42.15 47.54,42.24 47.54,42.65 47.44,42.74 47.24,42.74 47.14,42.65 47.14,42.24 47.04,42.15 46,42.15 45.9,42.24 45.9,42.65 45.8,42.74 45.6,42.74 45.5,42.65 45.5,42.23 45.4,42.12 45.2,42.12 45.1,42.23 45.1,42.66 45,42.76 44.8,42.76 44.7,42.66 44.7,42.24 44.6,42.15 44.34,42.15 44.06,42.43 43.74,42.43 43.52,42.2 43.52,41.92 43.23,41.63 42.68,41.63 v2(42.3,41.24)
DDR_DQ25: length 19.7
  TOP w0.102: U13.C2 v2(42.3,46.84) ; U2.J3 v2(53.25,46.9)
  INNER1 w0.1: v2(42.3,46.84) 42.56,46.84 42.94,47.23 43.79,47.23 43.89,47.13 43.89,46.58 43.99,46.48 44.19,46.48 44.29,46.58 44.29,47.35 44.39,47.45 44.59,47.45 44.69,47.35 44.69,46.63 44.79,46.53 44.99,46.53 45.09,46.63 45.09,47.13 45.19,47.23 45.51,47.23 45.67,47.06 45.67,46.92 45.53,46.78 45.53,46.64 45.67,46.5 45.81,46.5 45.95,46.64 46.09,46.64 46.25,46.48 47.09,46.48 47.19,46.38 47.19,45.98 47.29,45.88 47.49,45.88 47.59,45.98 47.59,46.38 47.69,46.48 47.89,46.48 47.99,46.38 47.99,45.98 48.09,45.88 48.29,45.88 48.39,45.98 48.39,46.38 48.49,46.48 49.83,46.48 49.93,46.38 49.93,45.88 50.03,45.78 50.23,45.78 50.33,45.88 50.33,46.38 50.43,46.48 50.74,46.48 51.05,46.79 51.58,46.79 52.06,47.28 52.87,47.28 v2(53.25,46.9)
DDR_DQ26: length 20
  TOP w0.102: U13.D7 v2(41.5,42.05) ; U2.L4 v2(54.25,44.9)
  INNER1 w0.1: v2(41.5,42.05) 42.06,42.61 42.61,42.61 42.75,42.75 42.75,42.88 42.39,43.24 42.39,43.38 42.54,43.52 42.67,43.52 43.03,43.17 43.17,43.17 43.36,43.36 43.91,43.36 44.01,43.46 44.01,43.56 44.11,43.66 44.31,43.66 44.41,43.56 44.41,43.46 44.51,43.36 44.71,43.36 44.81,43.46 44.81,43.56 44.91,43.66 45.11,43.66 45.21,43.56 45.21,43.46 45.31,43.36 45.88,43.36 46.49,43.98 47.35,43.98 47.45,44.08 47.45,44.48 47.55,44.58 47.75,44.58 47.85,44.48 47.85,44.08 47.95,43.98 48.28,43.98 48.5,44.2 49.81,44.2 49.91,44.3 49.91,44.7 50.01,44.8 50.21,44.8 50.31,44.7 50.31,44.3 50.41,44.2 50.7,44.2 50.98,44.48 51.24,44.48 51.34,44.58 51.34,44.98 51.45,45.08 51.64,45.08 51.74,44.98 51.74,44.58 51.84,44.48 53.83,44.48 v2(54.25,44.9)
DDR_DQ27: length 20.1
  TOP w0.102: U2.K3 v2(53.25,45.9) ; U13.D3 v2(41.5,46.05)
  INNER1 w0.1: v2(41.5,46.05) 42.3,45.24 42.75,45.24 42.85,45.15 42.85,44.65 42.95,44.55 43.15,44.55 43.25,44.65 43.25,45.15 43.35,45.24 43.8,45.24 44.19,45.63 44.32,45.63 44.78,45.17 44.92,45.17 45.06,45.32 45.06,45.46 44.61,45.91 44.61,46.05 44.8,46.24 45.57,46.24 45.67,46.15 45.67,45.24 45.77,45.15 45.97,45.15 46.07,45.24 46.07,46.15 46.17,46.24 46.54,46.24 47.08,45.7 47.46,45.7 47.56,45.6 47.56,45.5 47.66,45.4 47.86,45.4 47.96,45.5 47.96,45.6 48.06,45.7 48.44,45.7 48.94,46.2 49.35,46.2 49.95,45.6 50.31,45.6 50.52,45.8 50.52,45.96 51.02,46.46 52.29,46.46 52.85,45.9 v2(53.25,45.9)
DDR_DQ28: length 19.7
  TOP w0.102: U2.H4 v2(54.25,48.9) ; U13.D1 v2(41.5,47.65)
  INNER1 w0.1: v2(54.25,48.9) 53.48,48.13 53.19,48.13 53.09,48.03 53.09,47.93 52.99,47.83 52.79,47.83 52.69,47.93 52.69,48.03 52.59,48.13 52.39,48.13 52.29,48.03 52.29,47.93 52.19,47.83 51.99,47.83 51.89,47.93 51.89,48.03 51.79,48.13 51.59,48.13 51.49,48.03 51.49,47.93 51.39,47.83 51.19,47.83 51.09,47.93 51.09,48.03 50.99,48.13 50.79,48.13 50.69,48.03 50.69,47.93 50.59,47.83 50.39,47.83 50.29,47.93 50.29,48.03 50.19,48.13 49.91,48.13 49.31,48.73 48.6,48.73 48.5,48.63 48.5,48.43 48.4,48.33 48.2,48.33 48.1,48.43 48.1,48.63 48,48.73 47.8,48.73 47.7,48.63 47.7,48.43 47.6,48.33 47.4,48.33 47.3,48.43 47.3,48.63 47.2,48.73 45.92,48.73 45.82,48.63 45.82,48.53 45.72,48.43 45.52,48.43 45.42,48.53 45.42,48.63 45.32,48.73 45.12,48.73 45.02,48.63 45.02,48.53 44.92,48.43 44.72,48.43 44.62,48.53 44.62,48.66 44.52,48.76 44.32,48.76 44.22,48.66 44.22,48.53 44.12,48.43 43.92,48.43 43.82,48.53 43.82,48.63 43.72,48.73 43.52,48.73 43.42,48.63 43.42,48.53 43.32,48.43 43.12,48.43 43.02,48.53 43.02,48.63 42.92,48.73 42.58,48.73 42.28,48.42 42.14,48.42 42,48.57 41.86,48.57 41.72,48.42 41.72,48.28 41.86,48.14 41.86,48 v2(41.5,47.65)
DDR_DQ29: length 19.8
  TOP w0.102: U13.D9 v2(41.5,40.45) ; U2.N3 v2(53.25,42.9)
  INNER1 w0.1: v2(41.5,40.45) 41.88,40.83 43.23,40.83 43.52,41.12 43.52,41.4 43.78,41.66 44.06,41.66 44.34,41.95 44.6,41.95 44.7,41.84 44.7,41.34 44.8,41.24 45,41.24 45.1,41.34 45.1,41.84 45.2,41.95 45.4,41.95 45.5,41.84 45.5,41.34 45.6,41.24 45.8,41.24 45.9,41.34 45.9,41.84 46,41.95 47.22,41.95 47.32,41.84 47.32,41.45 47.42,41.34 47.62,41.34 47.72,41.45 47.72,41.84 47.82,41.95 48.02,41.95 48.12,41.84 48.12,41.45 48.22,41.34 48.42,41.34 48.52,41.45 48.52,41.84 48.62,41.95 48.82,41.95 49.09,42.21 49.85,42.21 49.95,42.31 49.95,42.7 50.05,42.8 50.25,42.8 50.35,42.7 50.35,42.31 50.45,42.21 50.77,42.21 51.02,42.46 51.26,42.46 51.36,42.56 51.36,42.66 51.46,42.76 51.66,42.76 51.76,42.66 51.76,42.56 51.86,42.46 52.81,42.46 v2(53.25,42.9)
DDR_DQ30: length 19.7
  TOP w0.102: U13.B1 v2(43.1,47.65) ; U2.J4 v2(54.25,46.9)
  INNER1 w0.1: v2(54.25,46.9) 53.61,47.53 53.61,47.53 53.42,47.53 53.36,47.47 51.59,47.47 51.49,47.37 51.49,47.07 51.39,46.97 51.19,46.97 51.09,47.07 51.09,47.37 50.99,47.47 50.79,47.47 50.69,47.37 50.69,47.07 50.59,46.97 50.39,46.97 50.29,47.07 50.29,47.37 50.19,47.47 49.91,47.47 49.5,47.06 49.1,47.06 49,46.96 49,46.76 48.9,46.66 48.7,46.66 48.6,46.76 48.6,47.41 48.5,47.51 48.3,47.51 48.2,47.41 48.2,46.76 48.1,46.66 47.9,46.66 47.8,46.76 47.8,47.46 47.7,47.56 47.5,47.56 47.4,47.46 47.4,46.76 47.3,46.66 47.1,46.66 47,46.76 47,46.96 46.9,47.06 46.5,47.06 46.2,47.35 46.06,47.35 45.92,47.21 45.78,47.21 45.64,47.35 45.64,47.49 45.78,47.64 45.78,47.77 45.49,48.07 45.18,48.07 45.08,47.97 45.08,47.77 44.98,47.67 44.78,47.67 44.68,47.77 44.68,47.97 44.58,48.07 43.52,48.07 v2(43.1,47.65)
DDR_DQ31: length 19.7
  TOP w0.102: U13.B9 v2(43.1,40.45) ; U2.N4 v2(54.25,42.9)
  INNER1 w0.1: v2(54.25,42.9) 53.63,42.28 51.09,42.28 50.55,41.73 50.41,41.73 50.12,42.02 49.98,42.02 49.84,41.87 49.84,41.73 50.12,41.45 50.12,41.31 49.64,40.83 48.6,40.83 48.5,40.93 48.5,41.03 48.4,41.13 48.2,41.13 48.1,41.03 48.1,40.93 48,40.83 47.8,40.83 47.7,40.93 47.7,41.03 47.6,41.13 47.4,41.13 47.3,41.03 47.3,40.93 47.2,40.83 45.97,40.83 45.87,40.73 45.87,39.73 45.77,39.63 45.57,39.63 45.47,39.73 45.47,40.85 45.37,40.95 45.17,40.95 45.07,40.85 45.07,39.73 44.97,39.63 44.77,39.63 44.67,39.73 44.67,40.73 44.57,40.83 43.48,40.83 v2(43.1,40.45)
DDS.DATA0: length 21.4
  TOP w0.102: U2.B10 v2(61.25,54.9)
  TOP w0.2: U4.4 72.5,64.9 v1(71.8,65.59)
  INNER1 w0.102: v2(61.25,54.9) 61.25,56.18 61.49,56.41
  INNER1 w0.2: 61.49,56.41 62.22,57.15 63.28,57.15 64.75,58.61 64.75,63.3 66.75,65.3 71.5,65.3 v1(71.8,65.59)
DDS.DATA1: length 24
  TOP w0.102: U2.C10 v2(61.25,53.9)
  TOP w0.2: U4.3 v1(75.1,65.55)
  INNER1 w0.102: 63.72,56.41 62.75,55.45 61.95,55.45 61.8,55.3 61.8,54.45 v2(61.25,53.9)
  INNER1 w0.2: v1(75.1,65.55) 74.41,65.55 73.36,64.5 67.12,64.5 65.55,62.93 65.55,58.28 63.72,56.45 63.72,56.41
DDS.DATA2: length 25
  TOP w0.102: U2.E10 v2(61.25,51.9)
  TOP w0.2: U4.2 72.34,66.2 v1(72.32,66.22)
  INNER1 w0.102: v2(61.25,51.9) 60.87,52.28 60.87,56.36 60.92,56.41
  INNER1 w0.2: 60.92,56.41 62.05,57.55 63.12,57.55 64.35,58.78 64.35,63.46 66.58,65.69 70.85,65.69 71.35,66.19 71.54,66.19 71.55,66.2 72.3,66.2 72.32,66.22 v1(72.32,66.22)
DDS.DATA3: length 29.7
  TOP w0.102: U2.F10 v2(61.25,50.9)
  TOP w0.2: U4.1 v1(75.1,66.85)
  INNER1 w0.102: 60.5,56.41 60.5,55.65 60.69,55.46 60.69,51.91 61.25,51.34 v2(61.25,50.9)
  INNER1 w0.2: v1(75.1,66.85) 71.41,66.85 70.65,66.09 66.42,66.09 63.95,63.63 63.95,58.94 62.95,57.95 61.88,57.95 61.48,57.55 61.4,57.55 60.5,56.65 60.5,56.41
DDS.DATA4: length 34.5
  TOP w0.102: U2.E11 v2(62.25,51.9)
  TOP w0.2: U4.28 v1(82.3,66.85)
  INNER2 w0.1: 66.98,55.08 67.63,55.74 67.63,56.41
  INNER2 w0.102: 66.98,55.08 66.16,55.08 65.93,54.86 65.93,53.57 64.6,52.24 62.6,52.24 v2(62.25,51.9)
  INNER2 w0.2: 67.63,56.41 67.63,56.84 69,58.21 69,62.65 70.05,63.7 72.94,63.7 74.69,61.95 75.62,61.95 76.8,63.13 76.8,63.15 76.8,63.15 76.8,63.48 76.8,64.34 78.05,65.59 81.05,65.59 v1(82.3,66.85)
DDS.DATA5: length 31.5
  TOP w0.102: U2.D11 v2(62.25,52.9)
  TOP w0.2: U4.27 v1(79.54,66.2)
  INNER2 w0.1: 65.75,53.65 65.75,54.93 66.08,55.26 66.58,55.26 66.83,55.52 66.83,56.01 67.05,56.23 67.05,56.41
  INNER2 w0.102: v2(62.25,52.9) 62.7,52.45 64.54,52.45 65.75,53.65
  INNER2 w0.2: v1(79.54,66.2) 79.5,66.25 78.15,66.25 77.9,66 77.88,66 76.4,64.51 76.4,63.3 75.45,62.34 74.85,62.34 73.1,64.09 69.84,64.09 68.6,62.86 68.6,58.38 67.05,56.83 67.05,56.41
DDS.DATA6: length 30.5
  TOP w0.102: U2.C11 v2(62.25,53.9)
  TOP w0.2: U4.26 v1(82.3,65.55)
  INNER1 w0.102: v2(62.25,53.9) 62.3,53.9 62.7,54.3 62.7,54.95 64.17,56.41 64.25,56.41
  INNER1 w0.2: v1(82.3,65.55) 82.3,65.55 81.05,65.55 79.8,64.3 78.1,64.3 77.45,64.94 74.38,64.94 73.53,64.09 67.4,64.09 65.95,62.65 65.95,58.11 64.25,56.41
DDS.DATA7: length 27.3
  TOP w0.102: U2.A11 v2(62.25,55.9)
  TOP w0.2: U4.25 v1(79.54,64.9)
  INNER1 w0.102: 62.25,56.41 v2(62.25,55.9)
  INNER1 w0.2: 62.25,56.41 62.25,56.55 62.45,56.74 63.45,56.74 65.15,58.45 65.15,63.09 66.95,64.9 73.19,64.9 74.45,66.16 76.89,66.16 78.14,64.9 v1(79.54,64.9)
DDS.FQUD: length 18
  TOP w0.102: U2.B12 v2(63.25,54.9)
  TOP w0.2: U4.8 v1(72.34,62.3)
  INNER1 w0.102: v2(63.25,54.9) 63.7,55.34 65.45,55.34 65.75,55.65 65.75,56.41
  INNER1 w0.2: v1(72.34,62.3) 72.34,62.3 71.3,62.3 70.66,62.94 67.46,62.94 66.75,62.23 66.75,57.78 65.75,56.78 65.75,56.41
DDS.RESET: length 26.4
  TOP w0.102: U2.A13 v2(64.25,55.9)
  TOP w0.2: U4.22 v1(82.3,62.95)
  INNER1 w0.102: 64.82,56.41 64.77,56.41 v2(64.25,55.9)
  INNER1 w0.2: 64.82,56.41 66.35,57.95 66.35,62.4 67.6,63.65 71.74,63.65 71.75,63.65 72.25,63.65 72.26,63.65 78.55,63.65 78.75,63.84 81.41,63.84 v1(82.3,62.95)
DDS.WCLK: length 20
  TOP w0.102: U2.A14 v2(65.25,55.9)
  TOP w0.2: U4.7 v1(75.1,62.95)
  INNER2 w0.1: 66.5,55.45 66.65,55.59 66.65,56.21
  INNER2 w0.102: v2(65.25,55.9) 65.25,55.84 65.65,55.45 66.5,55.45
  INNER2 w0.2: v1(75.1,62.95) 73.56,64.5 69.65,64.5 68.2,63.05 68.2,58.55 66.65,56.99 66.65,56.21
DDS_CLK: length 64.2
  TOP w0.2: U4.9 73.72,61.65 v1(71.7,61.65)
  INNER1 w0.2: v1(71.7,61.65) 72.9,61.65 74.63,59.91 74.63,37.38 73.1,35.84 73.1,33.7 71.05,31.64 65.3,31.64 64.6,30.95 64.6,27.84 62.05,25.3 49.79,25.3 L4.2
