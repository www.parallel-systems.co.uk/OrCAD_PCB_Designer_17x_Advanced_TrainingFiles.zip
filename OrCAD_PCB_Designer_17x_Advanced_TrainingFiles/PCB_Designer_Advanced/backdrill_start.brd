# Allegro board backdrill_start.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HL_B15: length 1.8
  TOP w0.127: 71.12,15.88 71.31,16.07 71.31,16.08 71.44,16.21 71.73,16.51 71.15,15.93 71.12,15.88
HL_B17: length 1.8
  TOP w0.127: 66.23,18.61 66.04,18.41 66.07,18.47 66.65,19.05 66.36,18.75 66.23,18.62 66.23,18.61
HL_B18: length 1.8
  TOP w0.127: 64.96,16.08 65.09,16.21 65.38,16.51 64.8,15.93 64.77,15.88 64.96,16.07 64.96,16.08
HL_B19: length 1.8
  TOP w0.127: 66.36,17.48 66.65,17.78 66.07,17.2 U3D1.T12 66.23,17.34 66.23,17.35 66.36,17.48
HLB_STB0: length 1.8
  TOP w0.127: 63.82,18.75 63.69,18.62 63.69,18.61 63.5,18.41 63.53,18.47 64.11,19.05 63.82,18.75
HLB_STB0_L: length 1.8
  TOP w0.127: 62.2,15.93 61.62,16.51 61.91,16.21 62.04,16.08 62.04,16.07 62.23,15.88 62.2,15.93
HLB_STB1: length 1.8
  TOP w0.127: 68.9,17.48 68.77,17.35 68.77,17.34 U3D1.T14 68.61,17.2 69.19,17.78 68.9,17.48
HLB_STB1_L: length 1.8
  TOP w0.127: 68.58,18.41 68.61,18.47 69.19,19.05 68.9,18.75 68.77,18.62 68.77,18.61 68.58,18.41
HLB_VREF_P64H: length 1.8
  TOP w0.127: U3D1.T16 71.15,17.2 71.73,17.78 71.44,17.48 71.31,17.35 71.31,17.34 U3D1.T16
HLB_ZCOM_FROM_P64H: length 1.8
  TOP w0.127: U3D1.T17 72.58,17.34 72.58,17.35 72.71,17.48 73,17.78 72.42,17.2 U3D1.T17
IRDY_L: length 56.6
  TOP w0.127: J4B1.B35 93.99,93.98 93.08,93.08 92.34,93.08 91.43,93.98 J3B2.B35 73.67,93.98 72.76,93.08 72.02,93.08 71.11,93.98 60.97,93.98 60.06,93.08 59.32,93.08 58.41,93.98 54.61,93.98
  LAYER_6 w0.127: J4B1.B35 104.8,93.98 107.77,91.01
P1_8V: length 3.5
  TOP w0.127: 60.93,19.74 v1(60.35,20.32) 60.64,20.02 60.77,19.89 60.77,19.88 U3D1.P8 60.93,19.74 ; v1(64.11,20.32) 63.53,19.74 U3D1.P10 63.69,19.88 63.69,19.89 63.82,20.02 v1(64.11,20.32)
P64H_66MHZ_CLK: length 1.8
  TOP w0.127: 72.39,18.41 72.58,18.61 72.58,18.62 72.71,18.75 73,19.05 72.42,18.47 72.39,18.41
P64H_APICCLK_PD: length 1.8
  TOP w0.127: 72.42,24.82 U3D1.K17 72.58,24.96 72.58,24.97 72.71,25.1 73,25.4 72.42,24.82
P64H_APICD0_PD: length 1.8
  TOP w0.127: 71.73,29.21 71.15,28.63 U3D1.G16 71.31,28.77 71.31,28.78 71.44,28.91 71.73,29.21
P64H_APICD1_PD: length 1.8
  TOP w0.127: 70.17,28.91 70.46,29.21 69.88,28.63 U3D1.G15 70.04,28.77 70.04,28.78 70.17,28.91
P66_ACK64_L: length 22.9
  TOP w0.127: 11.43,62.23 15.16,62.23 16.12,61.28 16.9,61.28 17.86,62.23 31.75,62.23 ; U3D1.F1 52.04,29.9 51.46,30.48 51.75,30.18 51.88,30.05 51.88,30.04 U3D1.F1
P66_AD0: length 22.9
  TOP w0.127: 51.88,32.59 51.88,32.58 U3D1.D1 52.04,32.44 51.46,33.02 51.75,32.72 51.88,32.59
  LAYER_8 w0.127: 36.83,64.77 33.1,64.77 32.14,63.82 31.36,63.82 30.4,64.77 16.51,64.77
P66_AD1: length 22.9
  TOP w0.127: 11.43,64.77 15.16,64.77 16.12,63.82 16.9,63.82 17.86,64.77 31.75,64.77 ; 51.88,33.85 U3D1.C1 52.04,33.71 51.46,34.29 51.75,33.99 51.88,33.86 51.88,33.85
P66_AD2: length 22.9
  TOP w0.127: 19.05,66.04 32.94,66.04 33.9,65.09 34.68,65.09 35.64,66.04 39.37,66.04 ; 51.88,35.12 U3D1.B1 52.04,34.98 51.46,35.56 51.75,35.26 51.88,35.13 51.88,35.12
P66_AD3: length 22.9
  TOP w0.127: 31.75,67.31 17.86,67.31 16.9,66.36 16.12,66.36 15.16,67.31 11.43,67.31 ; U3D1.D2 53.31,32.44 52.73,33.02 53.02,32.72 53.15,32.59 53.15,32.58 U3D1.D2
P66_AD4: length 22.9
  TOP w0.127: 53.15,31.32 53.15,31.31 U3D1.E2 53.31,31.17 52.73,31.75 53.02,31.45 53.15,31.32
  LAYER_8 w0.127: 39.37,68.58 35.64,68.58 34.68,67.63 33.9,67.63 32.94,68.58 19.05,68.58
P66_AD5: length 22.9
  TOP w0.127: 13.97,68.58 17.7,68.58 18.66,67.63 19.44,67.63 20.4,68.58 34.29,68.58 ; 53.15,33.85 U3D1.C2 53.31,33.71 52.73,34.29 53.02,33.99 53.15,33.86 53.15,33.85
P66_AD6: length 22.9
  TOP w0.127: 36.83,69.85 33.1,69.85 32.14,68.9 31.36,68.9 30.4,69.85 16.51,69.85 ; 52.73,35.56 53.02,35.26 53.15,35.13 53.15,35.12 U3D1.B2 53.31,34.98 52.73,35.56
P66_AD7: length 22.9
  TOP w0.127: 53.02,36.53 52.73,36.83 53.31,36.25 U3D1.A2 53.15,36.39 53.15,36.4 53.02,36.53
  BOTTOM w0.127: J2B2.B53 20.4,71.12 19.44,70.17 18.66,70.17 17.7,71.12 J2B1.B53
P66_AD8: length 22.9
  TOP w0.127: 54,31.75 54.58,31.17 U3D1.E3 54.42,31.31 54.42,31.32 54.29,31.45 54,31.75
  LAYER_8 w0.127: 31.75,72.39 17.86,72.39 16.9,71.44 16.12,71.44 15.16,72.39 11.43,72.39
P66_AD9: length 22.9
  TOP w0.127: 54,35.56 54.58,34.98 U3D1.B3 54.42,35.12 54.42,35.13 54.29,35.26 54,35.56
  LAYER_8 w0.127: 39.37,76.2 35.64,76.2 34.68,75.25 33.9,75.25 32.94,76.2 19.05,76.2
P66_AD10: length 22.9
  TOP w0.127: 55.69,32.58 55.69,32.59 55.56,32.72 55.27,33.02 55.85,32.44 U3D1.D4 55.69,32.58
  BOTTOM w0.127: J2B1.B48 15.16,77.47 16.12,76.52 16.9,76.52 17.83,77.44 19.71,77.44 19.74,77.47 J2B2.B48
P66_AD11: length 22.9
  TOP w0.127: 55.85,31.17 U3D1.E4 55.69,31.31 55.69,31.32 55.56,31.45 55.27,31.75 55.85,31.17
  LAYER_8 w0.127: 39.37,78.74 35.64,78.74 34.68,77.79 33.9,77.79 32.94,78.74 19.05,78.74
P66_AD12: length 22.9
  TOP w0.127: 55.56,33.99 55.27,34.29 55.85,33.71 U3D1.C4 55.69,33.85 55.69,33.86 55.56,33.99
  BOTTOM w0.127: J2B1.B47 17.55,78.74 18.54,77.75 19.58,77.75 20.57,78.74 J2B2.B47
P66_AD13: length 22.9
  TOP w0.127: 55.69,35.12 55.69,35.13 55.56,35.26 55.27,35.56 55.85,34.98 U3D1.B4 55.69,35.12
  BOTTOM w0.127: J2B1.A46 30.4,80.01 31.36,79.06 32.14,79.06 33.1,80.01 J2B2.A46
P66_AD14: length 22.9
  TOP w0.127: 55.69,36.39 U3D1.A4 55.85,36.25 55.27,36.83 55.56,36.53 55.69,36.4 55.69,36.39
  BOTTOM w0.127: J2B2.B45 20.4,81.28 19.44,80.33 18.66,80.33 17.7,81.28 J2B1.B45
P66_AD15: length 22.9
  TOP w0.127: 56.83,35.26 56.54,35.56 57.12,34.98 U3D1.B5 56.96,35.12 56.96,35.13 56.83,35.26
  LAYER_8 w0.127: 36.83,82.55 33.1,82.55 32.14,81.6 31.36,81.6 30.4,82.55 16.51,82.55
P66_AD16: length 22.9
  TOP w0.127: 61.91,32.72 62.04,32.59 62.04,32.58 U3D1.D9 62.2,32.44 61.62,33.02 61.91,32.72
  LAYER_8 w0.127: 36.83,97.79 33.1,97.79 32.14,96.84 31.36,96.84 30.4,97.79 16.51,97.79
P66_AD17: length 22.9
  TOP w0.127: U3D1.C9 62.2,33.71 61.62,34.29 61.91,33.99 62.04,33.86 62.04,33.85 U3D1.C9
  LAYER_5 w0.127: 11.43,97.79 15.16,97.79 16.12,96.84 16.9,96.84 17.86,97.79 31.75,97.79
P66_AD18: length 22.9
  TOP w0.127: 62.2,36.25 U3D1.A9 62.04,36.39 62.04,36.4 61.91,36.53 61.62,36.83 62.2,36.25
  LAYER_5 w0.127: 39.37,99.06 35.64,99.06 34.68,98.11 33.9,98.11 32.94,99.06 19.05,99.06
P66_AD19: length 22.9
  TOP w0.127: 63.69,32.58 63.69,32.59 63.82,32.72 64.11,33.02 63.53,32.44 U3D1.D10 63.69,32.58
  LAYER_5 w0.127: 11.43,100.33 15.16,100.33 16.12,99.38 16.9,99.38 17.86,100.33 31.75,100.33
P66_AD20: length 22.9
  TOP w0.127: U3D1.C10 63.53,33.71 64.11,34.29 63.82,33.99 63.69,33.86 63.69,33.85 U3D1.C10
  LAYER_8 w0.127: 39.37,101.6 35.64,101.6 34.68,100.65 33.9,100.65 32.94,101.6 19.05,101.6
P66_AD21: length 22.9
  TOP w0.127: 64.11,35.56 63.53,34.98 U3D1.B10 63.69,35.12 63.69,35.13 63.82,35.26 64.11,35.56
  LAYER_5 w0.127: 13.97,101.6 17.7,101.6 18.66,100.65 19.44,100.65 20.4,101.6 34.29,101.6
P66_AD22: length 22.9
  TOP w0.127: U3D1.A10 63.53,36.25 64.11,36.83 63.82,36.53 63.69,36.4 63.69,36.39 U3D1.A10
  LAYER_3 w0.127: 36.83,102.87 33.1,102.87 32.14,101.92 31.36,101.92 30.4,102.87 16.51,102.87
P66_AD23: length 22.9
  TOP w0.127: 65.09,32.72 65.38,33.02 64.8,32.44 U3D1.D11 64.96,32.58 64.96,32.59 65.09,32.72
  LAYER_3 w0.127: 34.29,104.14 20.4,104.14 19.44,103.19 18.66,103.19 17.7,104.14 13.97,104.14
P66_AD24: length 22.9
  TOP w0.127: U3D1.B11 64.96,35.12 64.96,35.13 65.09,35.26 65.38,35.56 64.8,34.98 U3D1.B11
  LAYER_8 w0.127: 39.37,106.68 35.64,106.68 34.68,105.73 33.9,105.73 32.94,106.68 19.05,106.68
P66_AD25: length 22.9
  TOP w0.127: 64.96,36.39 U3D1.A11 64.8,36.25 65.38,36.83 65.09,36.53 64.96,36.4 64.96,36.39
  LAYER_3 w0.127: 31.75,107.95 17.86,107.95 16.9,107 16.12,107 15.16,107.95 11.43,107.95
P66_AD26: length 124.8
  TOP w0.127: 66.23,32.59 66.36,32.72 66.65,33.02 66.07,32.44 U3D1.D12 66.23,32.58 66.23,32.59
  LAYER_6 w0.127: 39.37,109.22 39.42,109.22 40.61,108.03 40.61,40.92 42.9,38.63 66.7,38.63 66.83,38.51 66.83,37.37 67.16,37.04 67.16,34.08 66.83,33.75 66.83,33.2 66.65,33.02
  LAYER_8 w0.127: 39.37,109.22 35.64,109.22 34.68,108.27 33.9,108.27 32.94,109.22 19.05,109.22
P66_AD27: length 22.9
  TOP w0.127: 34.29,109.22 20.4,109.22 19.44,108.27 18.66,108.27 17.7,109.22 13.97,109.22 ; U3D1.C12 66.23,33.85 66.23,33.86 66.36,33.99 66.65,34.29 66.07,33.71 U3D1.C12
P66_AD28: length 22.9
  TOP w0.127: 16.51,110.49 30.4,110.49 31.36,109.54 32.14,109.54 33.1,110.49 36.83,110.49 ; U3D1.A12 66.07,36.25 66.65,36.83 66.36,36.53 66.23,36.4 66.23,36.39 U3D1.A12
P66_AD29: length 22.9
  TOP w0.127: 34.29,111.76 20.4,111.76 19.44,110.81 18.66,110.81 17.7,111.76 13.97,111.76 ; 67.34,33.71 U3D1.C13 67.5,33.85 67.5,33.86 67.63,33.99 67.92,34.29 67.34,33.71
P66_AD30: length 22.9
  TOP w0.127: 67.5,35.13 67.63,35.26 67.92,35.56 67.34,34.98 U3D1.B13 67.5,35.12 67.5,35.13
  LAYER_8 w0.127: 16.51,113.03 30.4,113.03 31.36,112.08 32.14,112.08 33.1,113.03 36.83,113.03
P66_AD31: length 22.9
  TOP w0.127: 11.43,113.03 15.16,113.03 16.12,112.08 16.9,112.08 17.86,113.03 31.75,113.03 ; 67.92,36.83 67.63,36.53 67.5,36.4 67.5,36.39 U3D1.A13 67.34,36.25 67.92,36.83
P66_AD32: length 37.5
  TOP w0.127: 19.05,20.32 32.94,20.32 33.9,19.37 34.68,19.37 35.64,20.32 47.12,20.32 50.8,16.64 52.19,16.64 52.51,16.96 52.51,17.34 52.83,17.65 U3D1.T2
P66_AD33: length 44.1
  TOP w0.127: 51.46,17.73 52.04,17.14 U3D1.T1
  LAYER_5 w0.127: 11.43,21.59 15.16,21.59 16.12,20.64 16.9,20.64 17.86,21.59 31.75,21.59
  LAYER_8 w0.127: 51.46,17.73 47.6,21.59 38.18,21.59 37.22,20.64 36.44,20.64 35.48,21.59 31.75,21.59
P66_AD34: length 22
  TOP w0.127: 55.3,19.02 55.25,18.97 55.8,18.41 55.88,18.41
  LAYER_3 w0.127: 19.05,22.86 32.94,22.86 33.9,21.91 34.68,21.91 35.64,22.86 39.37,22.86
P66_AD35: length 44.2
  TOP w0.127: 54.61,18.41 54.64,18.41 54.05,19
  LAYER_5 w0.127: 13.97,22.86 17.7,22.86 18.66,21.91 19.44,21.91 20.4,22.86 34.29,22.86
  LAYER_8 w0.127: 34.29,22.86 38.02,22.86 38.98,21.91 39.76,21.91 40.41,22.56 47.07,22.56 51.08,18.54 52.84,18.54 53.17,18.87 53.92,18.87 54.05,19
P66_AD36: length 22.1
  TOP w0.127: 53.26,18.52 53.24,18.52 ; 53.26,18.52 52.68,19.1 ; 53.26,18.52 53.34,18.41
  LAYER_5 w0.127: 36.83,24.13 33.1,24.13 32.14,23.18 31.36,23.18 30.4,24.13 16.51,24.13
P66_AD37: length 44.3
  TOP w0.127: 52.04,18.47 51.46,19.05 51.75,18.75 51.88,18.62 51.88,18.61 52.07,18.41 52.04,18.47
  LAYER_5 w0.127: 13.97,25.4 17.7,25.4 18.66,24.45 19.44,24.45 20.4,25.4 34.29,25.4
  LAYER_8 w0.127: 51.46,19.05 46.37,24.14 38.19,24.14 37.22,23.18 36.44,23.18 35.88,23.74 35.88,25.22 35.7,25.4 34.29,25.4
P66_AD38: length 22.9
  TOP w0.127: 55.69,19.89 55.69,19.88 U3D1.P4 55.85,19.74 55.27,20.32 55.56,20.02 55.69,19.89
  LAYER_3 w0.127: 36.83,26.67 33.1,26.67 32.14,25.72 31.36,25.72 30.4,26.67 16.51,26.67
P66_AD39: length 48.5
  TOP w0.127: 54,20.32 54.29,20.02 54.42,19.89 54.42,19.88 U3D1.P3 54.58,19.74 54,20.32
  LAYER_5 w0.127: 31.75,26.67 17.86,26.67 16.9,25.72 16.12,25.72 15.16,26.67 11.43,26.67
  LAYER_8 w0.127: 31.75,26.67 35.48,26.67 36.44,25.72 36.6,25.72 37.22,25.1 38.33,25.1 38.98,24.45 39.76,24.45 40.41,25.1 47.07,25.1 49.51,22.65 50.95,22.65 51.25,22.35 51.67,22.35 52.22,21.8 52.22,21.38 52.52,21.08 53.16,21.08 53.39,20.85 53.47,20.85 54,20.32
P66_AD40: length 38.1
  TOP w0.127: 51.46,20.32 52.04,19.74 U3D1.P1 51.88,19.88 51.88,19.89 51.75,20.02 51.46,20.32
  LAYER_5 w0.127: 19.05,27.94 32.94,27.94 33.9,26.99 34.68,26.99 35.64,27.94 41.45,27.94 48.41,20.98 50.8,20.98 51.46,20.32
P66_AD41: length 50
  TOP w0.127: 55.27,21.59 55.85,21.01 U3D1.N4 55.69,21.15 55.69,21.16 55.56,21.29 55.27,21.59
  LAYER_5 w0.127: 31.75,29.21 17.86,29.21 16.9,28.26 16.12,28.26 15.16,29.21 11.43,29.21
  LAYER_8 w0.127: 31.75,29.21 35.48,29.21 37.07,27.62 37.22,27.62 37.9,26.95 46.53,26.95 48.58,24.89 51.67,24.89 52.22,24.34 52.22,23.92 52.52,23.62 52.94,23.62 53.49,23.07 53.49,22.65 53.79,22.35 54.51,22.35 55.27,21.59
P66_AD42: length 22.9
  TOP w0.127: 54,21.59 54.29,21.29 54.42,21.16 54.42,21.15 U3D1.N3 54.58,21.01 54,21.59
  LAYER_3 w0.127: 19.05,30.48 32.94,30.48 33.9,29.53 34.68,29.53 35.64,30.48 39.37,30.48
P66_AD43: length 45.4
  TOP w0.127: 52.73,21.59 53.02,21.29 53.15,21.16 53.15,21.15 U3D1.N2 53.31,21.01 52.73,21.59
  LAYER_5 w0.127: 52.73,21.59 52.55,21.41 52,21.41 51.67,21.08 51.25,21.08 51.05,21.29 49.02,21.29 40.78,29.53 38.98,29.53 38.02,30.48 20.4,30.48 19.44,29.53 18.66,29.53 17.7,30.48 13.97,30.48
P66_AD44: length 41.7
  TOP w0.127: 51.75,21.29 51.46,21.59 52.04,21.01 U3D1.N1 51.88,21.15 51.88,21.16 51.75,21.29
  LAYER_5 w0.127: 51.46,21.59 50.62,21.59 40.46,31.75 33.1,31.75 32.14,30.8 31.36,30.8 30.4,31.75 16.51,31.75
P66_AD45: length 48.7
  TOP w0.127: 55.85,22.28 U3D1.M4 55.69,22.42 55.69,22.43 55.56,22.56 55.27,22.86 55.85,22.28
  LAYER_5 w0.127: 55.27,22.86 54.51,22.1 53.16,22.1 52.91,22.35 51.11,22.35 50.86,22.61 50.86,22.65 46.56,26.95 46.53,26.95 41.41,32.07 38.98,32.07 38.02,33.02 20.4,33.02 19.44,32.07 18.66,32.07 17.7,33.02 13.97,33.02
P66_AD46: length 22.9
  TOP w0.127: 54.29,22.56 54.42,22.43 54.42,22.42 U3D1.M3 54.58,22.28 54,22.86 54.29,22.56
  LAYER_3 w0.127: 16.51,34.29 30.4,34.29 31.36,33.34 32.14,33.34 33.1,34.29 36.83,34.29
P66_AD47: length 49.9
  TOP w0.127: 53.15,22.42 U3D1.M2 53.31,22.28 52.73,22.86 53.02,22.56 53.15,22.43 53.15,22.42
  LAYER_5 w0.127: 52.73,22.86 52.53,23.06 52.53,23.16 52.07,23.62 51.25,23.62 51.15,23.72 51.13,23.72 50.88,23.98 50.88,24.64 48.34,27.18 48.34,27.25 41.3,34.29 38.18,34.29 37.22,33.34 36.44,33.34 35.48,34.29 17.86,34.29 16.9,33.34 16.12,33.34 15.16,34.29 11.43,34.29
P66_AD48: length 22.9
  TOP w0.127: U3D1.M1 51.88,22.42 51.88,22.43 51.75,22.56 51.46,22.86 52.04,22.28 U3D1.M1
  LAYER_5 w0.127: 39.37,35.56 35.64,35.56 34.68,34.61 33.9,34.61 32.94,35.56 19.05,35.56
P66_AD49: length 22.9
  TOP w0.127: 55.27,24.13 55.85,23.55 U3D1.L4 55.69,23.69 55.69,23.7 55.56,23.83 55.27,24.13
  LAYER_5 w0.127: 11.43,36.83 15.16,36.83 16.12,35.88 16.9,35.88 17.86,36.83 31.75,36.83
P66_AD50: length 22.9
  TOP w0.127: 54.42,23.7 54.29,23.83 54,24.13 54.58,23.55 U3D1.L3 54.42,23.69 54.42,23.7
  LAYER_8 w0.127: 19.05,38.1 32.94,38.1 33.9,37.15 34.68,37.15 35.64,38.1 39.37,38.1
P66_AD51: length 22.9
  TOP w0.127: 53.15,23.7 53.15,23.69 U3D1.L2 53.31,23.55 52.73,24.13 53.02,23.83 53.15,23.7
  LAYER_5 w0.127: 34.29,38.1 20.4,38.1 19.44,37.15 18.66,37.15 17.7,38.1 13.97,38.1
P66_AD52: length 22.9
  TOP w0.127: 52.04,23.55 51.46,24.13 51.75,23.83 51.88,23.7 51.88,23.69 U3D1.L1 52.04,23.55
  LAYER_5 w0.127: 36.83,39.37 33.1,39.37 32.14,38.42 31.36,38.42 30.4,39.37 16.51,39.37
P66_AD53: length 22.9
  TOP w0.127: 55.69,24.96 55.69,24.97 55.56,25.1 55.27,25.4 55.85,24.82 U3D1.K4 55.69,24.96
  LAYER_5 w0.127: 34.29,40.64 20.4,40.64 19.44,39.69 18.66,39.69 17.7,40.64 13.97,40.64
P66_AD54: length 22.9
  TOP w0.127: 54.58,24.82 U3D1.K3 54.42,24.96 54.42,24.97 54.29,25.1 54,25.4 54.58,24.82
  LAYER_3 w0.127: 36.83,41.91 33.1,41.91 32.14,40.96 31.36,40.96 30.4,41.91 16.51,41.91
P66_AD55: length 22.9
  TOP w0.127: 51.88,24.96 U3D1.K1 52.04,24.82 51.46,25.4 51.75,25.1 51.88,24.97 51.88,24.96
  LAYER_5 w0.127: 31.75,41.91 17.86,41.91 16.9,40.96 16.12,40.96 15.16,41.91 11.43,41.91
P66_AD56: length 22.9
  TOP w0.127: 55.69,26.23 55.69,26.24 55.56,26.37 55.27,26.67 55.85,26.09 U3D1.J4 55.69,26.23
  LAYER_5 w0.127: 39.37,43.18 35.64,43.18 34.68,42.23 33.9,42.23 32.94,43.18 19.05,43.18
P66_AD57: length 22.9
  TOP w0.127: 54.29,26.37 54,26.67 54.58,26.09 U3D1.J3 54.42,26.23 54.42,26.24 54.29,26.37
  LAYER_5 w0.127: 11.43,44.45 15.16,44.45 16.12,43.5 16.9,43.5 17.86,44.45 31.75,44.45
P66_AD58: length 22.9
  TOP w0.127: 52.73,26.67 53.02,26.37 53.15,26.24 53.15,26.23 U3D1.J2 53.31,26.09 52.73,26.67
  LAYER_3 w0.127: 39.37,45.72 35.64,45.72 34.68,44.77 33.9,44.77 32.94,45.72 19.05,45.72
P66_AD59: length 22.9
  TOP w0.127: 51.75,26.37 51.88,26.24 51.88,26.23 U3D1.J1 52.04,26.09 51.46,26.67 51.75,26.37
  LAYER_5 w0.127: 13.97,45.72 17.7,45.72 18.66,44.77 19.44,44.77 20.4,45.72 34.29,45.72
P66_AD60: length 22.9
  TOP w0.127: 55.56,27.64 55.27,27.94 55.85,27.36 U3D1.H4 55.69,27.5 55.69,27.51 55.56,27.64
  LAYER_5 w0.127: 36.83,46.99 33.1,46.99 32.14,46.04 31.36,46.04 30.4,46.99 16.51,46.99
P66_AD61: length 22.9
  TOP w0.127: 54,27.94 54.58,27.36 U3D1.H3 54.42,27.5 54.42,27.51 54.29,27.64 54,27.94
  LAYER_5 w0.127: 34.29,48.26 20.4,48.26 19.44,47.31 18.66,47.31 17.7,48.26 13.97,48.26
P66_AD62: length 22.9
  TOP w0.127: 53.31,27.36 52.73,27.94 53.02,27.64 53.15,27.51 53.15,27.5 U3D1.H2 53.31,27.36
  LAYER_3 w0.127: 36.83,49.53 33.1,49.53 32.14,48.58 31.36,48.58 30.4,49.53 16.51,49.53
P66_AD63: length 22.9
  TOP w0.127: 51.75,27.64 51.88,27.51 51.88,27.5 U3D1.H1 52.04,27.36 51.46,27.94 51.75,27.64
  LAYER_5 w0.127: 11.43,49.53 15.16,49.53 16.12,48.58 16.9,48.58 17.86,49.53 31.75,49.53
P66_C_BE_L0: length 1.8
  TOP w0.127: 54,33.02 54.58,32.44 U3D1.D3 54.42,32.58 54.42,32.59 54.29,32.72 54,33.02
P66_C_BE_L1: length 22.9
  TOP w0.127: 56.96,36.4 56.96,36.39 U3D1.A5 57.12,36.25 56.54,36.83 56.83,36.53 56.96,36.4
  BOTTOM w0.127: J2B1.B44 15.16,82.55 16.12,81.6 16.9,81.6 17.86,82.55 J2B2.B44
P66_C_BE_L2: length 22.9
  TOP w0.127: 60.35,36.83 60.93,36.25 U3D1.A8 60.77,36.39 60.77,36.4 60.64,36.53 60.35,36.83
  LAYER_6 w0.127: 34.29,96.52 20.4,96.52 19.44,95.57 18.66,95.57 17.7,96.52 13.97,96.52
P66_C_BE_L3: length 22.9
  TOP w0.127: 64.96,33.85 U3D1.C11 64.8,33.71 65.38,34.29 65.09,33.99 64.96,33.86 64.96,33.85
  LAYER_3 w0.127: 31.75,105.41 17.86,105.41 16.9,104.46 16.12,104.46 15.16,105.41 11.43,105.41
P66_C_BE_L4: length 22.9
  TOP w0.127: 57.12,28.63 U3D1.G5 56.96,28.77 56.96,28.78 56.83,28.91 56.54,29.21 57.12,28.63
  LAYER_5 w0.127: 31.75,52.07 17.86,52.07 16.9,51.12 16.12,51.12 15.16,52.07 11.43,52.07
P66_C_BE_L5: length 22.9
  TOP w0.127: U3D1.G3 54.42,28.77 54.42,28.78 54.29,28.91 54,29.21 54.58,28.63 U3D1.G3
  LAYER_3 w0.127: 39.37,53.34 35.64,53.34 34.68,52.39 33.9,52.39 32.94,53.34 19.05,53.34
P66_C_BE_L6: length 22.9
  TOP w0.127: 53.31,28.63 52.73,29.21 53.02,28.91 53.15,28.78 53.15,28.77 U3D1.G2 53.31,28.63
  LAYER_5 w0.127: 13.97,53.34 17.7,53.34 18.66,52.39 19.44,52.39 20.4,53.34 34.29,53.34
P66_C_BE_L7: length 22.9
  TOP w0.127: 51.88,28.77 U3D1.G1 52.04,28.63 51.46,29.21 51.75,28.91 51.88,28.78 51.88,28.77
  LAYER_5 w0.127: 16.51,54.61 30.4,54.61 31.36,53.66 32.14,53.66 33.1,54.61 36.83,54.61
P66_DEVSEL_L: length 22.9
  TOP w0.127: 59.5,36.39 59.5,36.4 59.37,36.53 59.08,36.83 59.66,36.25 U3D1.A7 59.5,36.39
  LAYER_6 w0.127: 13.97,91.44 17.7,91.44 18.66,90.49 19.44,90.49 20.4,91.44 34.29,91.44
P66_FRAME_L: length 22.9
  TOP w0.127: 60.77,35.12 U3D1.B8 60.93,34.98 60.35,35.56 60.64,35.26 60.77,35.13 60.77,35.12
  LAYER_6 w0.127: 36.83,95.25 33.1,95.25 32.14,94.3 31.36,94.3 30.4,95.25 16.51,95.25
P66_GNT_L0: length 136.5
  TOP w0.127: 73,35.56 72.42,34.98 U3D1.B17 72.58,35.12 72.58,35.13 72.71,35.26 73,35.56
  LAYER_5 w0.127: 73,35.56 72.24,36.32 71.52,36.32 71.22,36.62 71.22,39.73 70.46,40.49 44.93,40.49 43.84,41.58 43.84,116.28 43.28,116.84 40.72,116.84 39.76,115.89 38.98,115.89 38.02,116.84 35.64,116.84 34.68,115.89 33.9,115.89 32.94,116.84 19.05,116.84
P66_GNT_L1: length 116
  TOP w0.127: 71.15,33.71 U3D1.C16 71.31,33.85 71.31,33.86 71.44,33.99 71.73,34.29 71.15,33.71
  LAYER_6 w0.127: 39.37,116.84 41.17,116.84 41.3,116.71 41.3,41.25 43,39.55 71.42,39.55 72.01,38.96 72.01,37.27 72.24,37.04 72.24,36.62 72.01,36.39 72.01,36 72.24,35.77 72.24,35.35 72.01,35.12 72.01,34.57 71.73,34.29
P66_IRDY_L: length 22.9
  TOP w0.127: U3D1.C8 60.93,33.71 60.35,34.29 60.64,33.99 60.77,33.86 60.77,33.85 U3D1.C8
  LAYER_6 w0.127: 13.97,93.98 17.7,93.98 18.66,93.03 19.44,93.03 20.4,93.98 34.29,93.98
P66_IRQ_L0: length 1.8
  TOP w0.127: U3D1.P17 72.42,19.74 73,20.32 72.71,20.02 72.58,19.89 72.58,19.88 U3D1.P17
P66_IRQ_L1: length 1.8
  TOP w0.127: 71.44,20.02 71.31,19.89 71.31,19.88 U3D1.P16 71.15,19.74 71.73,20.32 71.44,20.02
P66_IRQ_L2: length 1.8
  TOP w0.127: 69.88,19.74 70.46,20.32 70.17,20.02 70.04,19.89 70.04,19.88 U3D1.P15 69.88,19.74
P66_IRQ_L3: length 1.8
  TOP w0.127: 72.58,21.16 72.58,21.15 U3D1.N17 72.42,21.01 73,21.59 72.71,21.29 72.58,21.16
P66_IRQ_L4: length 179.1
  TOP w0.127: 71.44,21.29 71.73,21.59 71.15,21.01 U3D1.N16 71.31,21.15 71.31,21.16 71.44,21.29
  LAYER_5 w0.127: 77.34,20.22 77.34,24.39 77.5,24.54 77.5,41.94 75.9,43.54 48.08,43.54 47.78,43.84 47.78,129.39 46.71,130.45 39.8,130.45 39.76,130.49 38.98,130.49 38.94,130.45 37.82,130.45 37.22,129.86 36.44,129.86 35.48,130.81 33.1,130.81 32.14,129.86 31.36,129.86 30.4,130.81 16.51,130.81
  LAYER_6 w0.127: 77.34,20.22 77.34,20.5 76.84,21.01 72.31,21.01 71.73,21.59
P66_IRQ_L5: length 179.6
  TOP w0.127: 69.88,21.01 70.46,21.59 70.17,21.29 70.04,21.16 70.04,21.15 U3D1.N15 69.88,21.01
  LAYER_5 w0.127: 76.05,20.29 76.05,41.27 74.8,42.52 47.09,42.52 46.66,42.95 46.66,127.81 45.52,128.96 40.13,128.96 39.76,128.59 38.98,128.59 38.02,129.54 35.64,129.54 34.68,128.59 33.9,128.59 32.94,129.54 20.4,129.54 19.44,128.59 18.66,128.59 17.7,129.54 13.97,129.54
  LAYER_8 w0.127: 76.05,20.29 73.69,20.29 73.21,19.81 72.79,19.81 72.24,20.36 72.24,20.53 71.94,20.83 71.22,20.83 70.46,21.59
P66_IRQ_L6: length 183
  TOP w0.127: 68.77,21.15 68.77,21.16 68.9,21.29 69.19,21.59 68.61,21.01 U3D1.N14 68.77,21.15
  LAYER_3 w0.127: 69.19,21.59 69.7,22.1 73.21,22.1 73.24,22.07 77.98,22.07 79.76,20.29
  LAYER_6 w0.127: 19.05,129.54 32.94,129.54 33.9,130.49 34.46,130.49 36.09,132.13 37.08,132.13 38.07,131.14 38.96,131.14 38.98,131.13 46.98,131.13 48.18,129.92 48.18,45.26 49.2,44.25 74.47,44.25 78.18,40.54 78.18,21.89 79.76,20.32 79.76,20.29 ; 69.95,22.35 69.19,21.59
P66_IRQ_L7: length 170.3
  TOP w0.127: 73,22.86 72.71,22.56 72.58,22.43 72.58,22.42 U3D1.M17 72.42,22.28 73,22.86
  LAYER_5 w0.127: 73,22.86 74.17,24.03 74.17,40.06 72.62,41.61 46.13,41.61 45.14,42.6 45.14,127.05 44.87,127.32 40.4,127.32 39.76,127.95 38.98,127.95 38.34,127.32 36.44,127.32 35.48,128.27 33.1,128.27 32.14,127.32 31.36,127.32 30.4,128.27 17.86,128.27 16.9,127.32 16.12,127.32 15.16,128.27 11.43,128.27
P66_IRQ_L8: length 152
  TOP w0.127: 70.04,22.42 U3D1.M15 69.88,22.28 70.46,22.86 70.17,22.56 70.04,22.43 70.04,22.42
  LAYER_6 w0.127: 36.83,130.81 36.83,130.2 38.61,128.42 45.39,128.42 46.02,127.79 46.02,42.77 46.66,42.14 74.5,42.14 76.79,39.85 76.79,27.46 77.44,26.8 77.44,26.13 75.95,24.64 72.79,24.64 72.24,24.09 72.24,23.92 71.69,23.37 71.52,23.37 71.33,23.18 70.78,23.18 70.46,22.86
P66_IRQ_L9: length 155.1
  TOP w0.127: 68.77,22.43 68.9,22.56 69.19,22.86 68.61,22.28 U3D1.M14 68.77,22.42 68.77,22.43
  LAYER_6 w0.127: 34.29,129.54 34.29,128.7 35.67,127.32 37.4,127.32 38.38,126.34 38.68,126.34 38.98,126.05 39.76,126.05 40.06,126.34 43.71,126.34 44.35,125.7 44.35,41.58 44.98,40.94 74.73,40.94 76.05,39.62 76.05,27.35 76.42,26.97 76.84,26.97 77.14,26.68 77.14,26.26 76.84,25.96 76.42,25.96 76.37,25.91 72.79,25.91 72.49,25.61 72.49,24.77 72.36,24.64 70.25,24.64 69.95,24.34 69.95,23.62 69.19,22.86
P66_IRQ_L10: length 154.9
  TOP w0.127: 73,24.13 72.42,23.55 U3D1.L17 72.58,23.69 72.58,23.7 72.71,23.83 73,24.13 ; 73,24.13 73.05,24.08 75.97,24.08 78.51,21.54 78.51,20.29
  LAYER_6 w0.127: 78.51,20.29 77.75,21.06 77.75,26.93 77.52,27.16 77.52,40.13 74.57,43.08 47.88,43.08 47.24,43.71 47.24,128.91 46.61,129.54 39.37,129.54
P66_IRQ_L11: length 151.8
  TOP w0.127: 71.31,23.7 71.44,23.83 71.73,24.13 71.15,23.55 U3D1.L16 71.31,23.69 71.31,23.7
  LAYER_3 w0.127: 71.73,24.13 72.28,24.13 72.79,23.62 73.21,23.62 73.72,24.13 75.97,24.13 76.63,24.79 76.63,26.47
  LAYER_6 w0.127: 31.75,128.27 32.74,128.27 33.34,127.67 33.34,126.61 33.9,126.05 34.96,126.05 37.52,123.49 42.24,123.49 42.88,122.86 42.88,41.38 44.12,40.13 74.57,40.13 75.36,39.34 75.36,26.8 75.69,26.47 76.63,26.47
P66_IRQ_L12: length 1.8
  TOP w0.127: U3D1.L15 70.04,23.69 70.04,23.7 70.17,23.83 70.46,24.13 69.88,23.55 U3D1.L15
P66_IRQ_L13: length 1.8
  TOP w0.127: 68.9,23.83 69.19,24.13 68.61,23.55 U3D1.L14 68.77,23.69 68.77,23.7 68.9,23.83
P66_IRQ_L14: length 1.8
  TOP w0.127: 71.31,24.97 71.44,25.1 71.73,25.4 71.15,24.82 U3D1.K16 71.31,24.96 71.31,24.97
P66_IRQ_L15: length 1.8
  TOP w0.127: 70.46,25.4 69.88,24.82 U3D1.K15 70.04,24.96 70.04,24.97 70.17,25.1 70.46,25.4
P66_IRQ_L16: length 1.8
  TOP w0.127: 69.19,25.4 68.61,24.82 U3D1.K14 68.77,24.96 68.77,24.97 68.9,25.1 69.19,25.4
P66_IRQ_L17: length 1.8
  TOP w0.127: U3D1.J17 72.58,26.23 72.58,26.24 72.71,26.37 73,26.67 72.42,26.09 U3D1.J17
P66_IRQ_L18: length 1.8
  TOP w0.127: 70.04,26.24 70.17,26.37 70.46,26.67 69.88,26.09 U3D1.J15 70.04,26.23 70.04,26.24
P66_IRQ_L19: length 1.8
  TOP w0.127: U3D1.J14 68.77,26.23 68.77,26.24 68.9,26.37 69.19,26.67 68.61,26.09 U3D1.J14
P66_IRQ_L20: length 1.8
  TOP w0.127: 71.15,27.36 U3D1.H16 71.31,27.5 71.31,27.51 71.44,27.64 71.73,27.94 71.15,27.36
P66_IRQ_L21: length 1.8
  TOP w0.127: 70.46,27.94 69.88,27.36 U3D1.H15 70.04,27.5 70.04,27.51 70.17,27.64 70.46,27.94
P66_IRQ_L22: length 1.8
  TOP w0.127: 68.61,27.36 U3D1.H14 68.77,27.5 68.77,27.51 68.9,27.64 69.19,27.94 68.61,27.36
P66_IRQ_L23: length 1.8
  TOP w0.127: 72.58,28.77 72.58,28.78 72.71,28.91 73,29.21 72.42,28.63 U3D1.G17 72.58,28.77
P66_LOCK_L: length 22.9
  TOP w0.127: 59.37,33.99 59.5,33.86 59.5,33.85 U3D1.C7 59.66,33.71 59.08,34.29 59.37,33.99
  LAYER_8 w0.127: 13.97,88.9 17.7,88.9 18.66,87.95 19.44,87.95 20.4,88.9 34.29,88.9
P66_M66EN: length 22.9
  TOP w0.127: U3D1.A3 54.58,36.25 54,36.83 54.29,36.53 54.42,36.4 54.42,36.39 U3D1.A3
  BOTTOM w0.127: J2B1.B49 17.7,76.2 18.66,75.25 19.44,75.25 20.4,76.2 J2B2.B49
P66_PAR: length 22.9
  TOP w0.127: U3D1.D6 58.23,32.58 58.23,32.59 58.1,32.72 57.81,33.02 58.39,32.44 U3D1.D6
  LAYER_8 w0.127: 39.37,83.82 35.64,83.82 34.68,82.87 33.9,82.87 32.94,83.82 19.05,83.82
P66_PAR64: length 22.9
  TOP w0.127: 55.69,28.78 55.56,28.91 55.27,29.21 55.85,28.63 U3D1.G4 55.69,28.77 55.69,28.78
  LAYER_5 w0.127: 19.05,50.8 32.94,50.8 33.9,49.85 34.68,49.85 35.64,50.8 39.37,50.8
P66_PCIRST_L: length 21.1
  LAYER_3 w0.127: 39.37,119.38 35.64,119.38 34.68,118.43 33.9,118.43 32.94,119.38 19.05,119.38
P66_PERR_L: length 22.9
  TOP w0.127: 59.5,32.59 59.5,32.58 U3D1.D7 59.66,32.44 59.08,33.02 59.37,32.72 59.5,32.59
  LAYER_8 w0.127: 31.75,87.63 17.86,87.63 16.9,86.68 16.12,86.68 15.16,87.63 11.43,87.63
P66_REQ64_L: length 22.9
  TOP w0.127: 54.29,30.18 54,30.48 54.58,29.9 U3D1.F3 54.42,30.04 54.42,30.05 54.29,30.18
  LAYER_8 w0.127: 16.51,62.23 30.4,62.23 31.36,61.28 32.14,61.28 33.1,62.23 36.83,62.23
P66_REQ_L0: length 139.4
  TOP w0.127: 70.04,36.4 70.04,36.39 U3D1.A15 69.88,36.25 70.46,36.83 70.17,36.53 70.04,36.4
  LAYER_5 w0.127: 70.46,36.83 70.23,37.06 70.23,37.97 68.35,39.85 43.81,39.85 42.29,41.38 42.29,114.93
  BOTTOM w0.127: 42.29,114.93 41.53,114.93 41.21,115.25 37.93,115.25 37.3,114.62 35.78,114.62 35.1,115.29 34.14,115.29 32.79,116.64 22.12,116.64 21.18,115.7 18.87,115.7 17.79,114.62 15.68,114.62 15.05,115.25 13.58,115.25 13.33,115 12,115 11.43,115.57
P66_REQ_L1: length 1.8
  TOP w0.127: 69.19,33.02 68.61,32.44 U3D1.D14 68.77,32.58 68.77,32.59 68.9,32.72 69.19,33.02
P66_REQ_L2: length 1.8
  TOP w0.127: 68.61,33.71 U3D1.C14 68.77,33.85 68.77,33.86 68.9,33.99 69.19,34.29 68.61,33.71
P66_REQ_L3: length 1.8
  TOP w0.127: 68.61,34.98 U3D1.B14 68.77,35.12 68.77,35.13 68.9,35.26 69.19,35.56 68.61,34.98
P66_REQ_L4: length 1.8
  TOP w0.127: 68.77,36.4 68.77,36.39 U3D1.A14 68.61,36.25 69.19,36.83 68.9,36.53 68.77,36.4
P66_REQ_L5: length 1.8
  TOP w0.127: 67.5,32.58 67.5,32.59 67.63,32.72 67.92,33.02 67.34,32.44 U3D1.D13 67.5,32.58
P66_SERR_L: length 22.9
  TOP w0.127: 58.23,33.86 58.1,33.99 57.81,34.29 58.39,33.71 U3D1.C6 58.23,33.85 58.23,33.86
  LAYER_8 w0.127: 31.75,85.09 17.86,85.09 16.9,84.14 16.12,84.14 15.16,85.09 11.43,85.09
P66_STOP_L: length 22.9
  TOP w0.127: U3D1.B7 59.66,34.98 59.08,35.56 59.37,35.26 59.5,35.13 59.5,35.12 U3D1.B7
  LAYER_8 w0.127: 16.51,90.17 30.4,90.17 31.36,89.22 32.14,89.22 33.1,90.17 36.83,90.17
P66_TCK: length 21.1
  LAYER_3 w0.127: 11.43,135.89 15.16,135.89 16.12,134.94 16.9,134.94 17.86,135.89 31.75,135.89
P66_TDI: length 21.1
  LAYER_3 w0.127: 16.51,133.35 30.4,133.35 31.36,132.4 32.14,132.4 33.1,133.35 36.83,133.35
P66_TMS: length 21.1
  TOP w0.127: 19.05,134.62 32.94,134.62 33.9,133.67 34.68,133.67 35.64,134.62 39.37,134.62
P66_TRDY_L: length 22.9
  TOP w0.127: 60.93,32.44 60.35,33.02 60.64,32.72 60.77,32.59 60.77,32.58 U3D1.D8 60.93,32.44
  LAYER_6 w0.127: 16.51,92.71 30.4,92.71 31.36,91.76 32.14,91.76 33.1,92.71 36.83,92.71
P66_TRST_L: length 21.1
  LAYER_3 w0.127: 39.37,137.16 36.06,137.16 35.12,136.22 33.46,136.22 32.52,137.16 19.05,137.16
P_PME_L: length 75.9
  LAYER_3 w0.127: 92.71,114.3 78.75,114.3 77.84,113.4 77.1,113.4 76.19,114.3 55.89,114.3 54.98,113.4 54.24,113.4 53.33,114.3 35.64,114.3 34.68,113.35 33.9,113.35 32.94,114.3 J2B1.A19
PAR_L: length 33.8
  LAYER_8 w0.127: 92.71,83.82 78.75,83.82 77.84,82.92 77.1,82.92 76.19,83.82 59.69,83.82
PCI6_66MHZ_CLK: length 1.8
  TOP w0.127: 51.46,31.75 51.75,31.45 51.88,31.32 51.88,31.31 U3D1.E1 52.04,31.17 51.46,31.75
PCIRST_L: length 33.8
  LAYER_6 w0.127: 59.69,119.38 76.19,119.38 77.1,118.48 77.84,118.48 78.75,119.38 92.71,119.38
PERR_L: length 50.5
  TOP w0.127: J4B1.B40 96.53,87.63 95.62,86.73 94.88,86.73 93.97,87.63 J3B2.B40 76.21,87.63 75.3,86.73 74.56,86.73 73.65,87.63 58.43,87.63 57.52,86.73 56.78,86.73 55.87,87.63 52.07,87.63
PIRQ_A_L: length 18.5
  LAYER_3 w0.127: 72.39,129.54 60.97,129.54 60.06,130.44 59.32,130.44 58.41,129.54 54.61,129.54
PIRQ_B_L: length 24.7
  LAYER_3 w0.127: 80.01,128.27 78.37,129.91 78.37,129.91 77.48,130.81 76.21,130.81 75.3,129.91 74.56,129.91 73.65,130.81 57.15,130.81
PIRQ_C_L: length 16.5
  LAYER_8 w0.127: 74.93,130.81 73.66,129.54 73.66,129.53 72.76,128.64 72.02,128.64 71.11,129.54 59.69,129.54
PIRQ_D_L: length 27.4
  LAYER_3 w0.127: 77.47,129.54 76.2,128.27 76.2,128.26 75.3,127.37 74.56,127.37 73.65,128.27 58.43,128.27 57.52,127.37 56.78,127.37 55.87,128.27 52.07,128.27
PIRQ_E_L: length 1.8
  TOP w0.127: U3D1.G14 68.77,28.77 68.77,28.78 68.9,28.91 69.19,29.21 68.61,28.63 U3D1.G14
PLOCK_L: length 56.8
  TOP w0.127: 54.61,88.9 58.41,88.9 59.32,88 60.06,88 60.97,88.9 71.11,88.9 72.02,88 72.76,88 73.67,88.9 J3B2.B39 91.43,88.9 92.34,88 93.08,88 93.99,88.9 J4B1.B39
  BOTTOM w0.127: J4B1.B39 104.34,88.9 J7A2.12
R_HL_B11: length 1.8
  TOP w0.127: 68.61,19.74 69.19,20.32 68.9,20.02 68.77,19.89 68.77,19.88 U3D1.P14 68.61,19.74
SERR_L: length 58.9
  LAYER_8 w0.127: 100.33,85.09 96.53,85.09 95.62,84.19 94.88,84.19 93.97,85.09 76.21,85.09 75.3,84.19 74.56,84.19 73.65,85.09 58.43,85.09 57.52,84.19 56.78,84.19 55.87,85.09 52.07,85.09
  BOTTOM w0.127: 100.33,85.09 105.38,85.09 J7A2.13
STOP_L: length 38.8
  TOP w0.127: 57.15,90.17 J3B2.A38 78.73,90.17 79.64,89.27 80.38,89.27 81.29,90.17 J4B1.A38
TCLK: length 50.5
  LAYER_6 w0.127: 52.07,135.89 55.87,135.89 56.78,134.99 57.52,134.99 58.43,135.89 73.65,135.89 74.56,134.99 75.3,134.99 76.21,135.89 93.97,135.89 94.88,134.99 96.88,134.99 97.42,135.52 99.96,135.52 100.33,135.89
TDI: length 38.8
  LAYER_6 w0.127: 95.25,133.35 94.88,132.98 92.34,132.98 91.8,132.45 79.64,132.45 78.73,133.35 57.15,133.35
TMS: length 33.8
  LAYER_6 w0.127: 92.71,134.62 92.34,134.25 79.64,134.25 79.1,133.72 77.1,133.72 76.19,134.62 59.69,134.62
TP_HP_INTR_L: length 1.8
  TOP w0.127: 59.5,16.08 59.37,16.21 59.08,16.51 59.66,15.93 59.69,15.88 59.5,16.07 59.5,16.08
TP_HP_SIC: length 0.8
  TOP w0.127: 52.78,16.43 53.37,15.85
TP_HP_SILB: length 0.9
  TOP w0.127: 54,17.7 54.58,17.12 U3D1.T3
TP_HP_SOC: length 1.8
  TOP w0.127: 56.54,21.59 56.83,21.29 56.96,21.16 56.96,21.15 U3D1.N5 57.12,21.01 56.54,21.59
TP_HP_SOD: length 1.8
  TOP w0.127: 57.12,17.2 U3D1.T5 56.96,17.34 56.96,17.35 56.83,17.48 56.54,17.78 57.12,17.2
TP_HP_SOL: length 1.8
  TOP w0.127: 56.54,20.32 56.83,20.02 56.96,19.89 56.96,19.88 U3D1.P5 57.12,19.74 56.54,20.32
TP_HP_SOLR: length 1.8
  TOP w0.127: 56.54,19.05 57.12,18.47 57.15,18.41 56.96,18.61 56.96,18.62 56.83,18.75 56.54,19.05
TP_HP_SORB: length 0.8
  TOP w0.127: 55.3,17.73 U3D1.T4
TP_HP_SORRB: length 0.9
  TOP w0.127: 55.27,16.46 55.85,15.88 55.88,15.88
TP_P64H_A6: length 1.8
  TOP w0.127: U3D1.A6 58.39,36.25 57.81,36.83 58.1,36.53 58.23,36.4 58.23,36.39 U3D1.A6
TP_P64H_A16: length 1.8
  TOP w0.127: 71.73,36.83 71.44,36.53 71.31,36.4 71.31,36.39 U3D1.A16 71.15,36.25 71.73,36.83
TP_P64H_B15: length 1.8
  TOP w0.127: 70.04,35.12 70.04,35.13 70.17,35.26 70.46,35.56 69.88,34.98 U3D1.B15 70.04,35.12
TP_P64H_B16: length 1.8
  TOP w0.127: 71.15,34.98 U3D1.B16 71.31,35.12 71.31,35.13 71.44,35.26 71.73,35.56 71.15,34.98
TP_P64H_C5: length 1.8
  TOP w0.127: 56.83,33.99 56.54,34.29 57.12,33.71 U3D1.C5 56.96,33.85 56.96,33.86 56.83,33.99
TP_P64H_C15: length 1.8
  TOP w0.127: U3D1.C15 70.04,33.85 70.04,33.86 70.17,33.99 70.46,34.29 69.88,33.71 U3D1.C15
TP_P64H_D5: length 1.8
  TOP w0.127: 56.96,32.58 56.96,32.59 56.83,32.72 56.54,33.02 57.12,32.44 U3D1.D5 56.96,32.58
TP_P64H_D15: length 1.8
  TOP w0.127: 69.88,32.44 U3D1.D15 70.04,32.58 70.04,32.59 70.17,32.72 70.46,33.02 69.88,32.44
TP_P64H_D17: length 1.8
  TOP w0.127: 73,33.02 72.42,32.44 U3D1.D17 72.58,32.58 72.58,32.59 72.71,32.72 73,33.02
TP_P64H_E6: length 1.8
  TOP w0.127: 58.1,31.45 57.81,31.75 58.39,31.17 U3D1.E6 58.23,31.31 58.23,31.32 58.1,31.45
TP_P64H_E15: length 1.8
  TOP w0.127: 70.04,31.31 70.04,31.32 70.17,31.45 70.46,31.75 69.88,31.17 U3D1.E15 70.04,31.31
TP_P64H_E16: length 1.8
  TOP w0.127: 71.31,31.32 71.44,31.45 71.73,31.75 71.15,31.17 U3D1.E16 71.31,31.31 71.31,31.32
TP_P64H_E17: length 1.8
  TOP w0.127: 72.58,31.31 72.58,31.32 72.71,31.45 73,31.75 72.42,31.17 U3D1.E17 72.58,31.31
TP_P64H_F15: length 1.8
  TOP w0.127: 70.46,30.48 69.88,29.9 U3D1.F15 70.04,30.04 70.04,30.05 70.17,30.18 70.46,30.48
TP_P64H_F17: length 1.8
  TOP w0.127: 72.58,30.04 72.58,30.05 72.71,30.18 73,30.48 72.42,29.9 U3D1.F17 72.58,30.04
TP_P64H_R6: length 1.8
  TOP w0.127: 58.39,18.47 57.81,19.05 58.1,18.75 58.23,18.62 58.23,18.61 58.42,18.41 58.39,18.47
TP_P64H_R7: length 1.8
  TOP w0.127: 59.5,18.62 59.37,18.75 59.08,19.05 59.66,18.47 59.69,18.41 59.5,18.61 59.5,18.62
TP_P64H_T6: length 1.8
  TOP w0.127: 58.23,17.35 58.1,17.48 57.81,17.78 58.39,17.2 U3D1.T6 58.23,17.34 58.23,17.35
TP_P64H_TEST: length 1.8
  TOP w0.127: 71.73,26.67 71.15,26.09 U3D1.J16 71.31,26.23 71.31,26.24 71.44,26.37 71.73,26.67
TP_P64H_U3: length 0.9
  TOP w0.127: 54,16.46 54.58,15.88 54.61,15.88
TP_P64HR8: length 1.8
  TOP w0.127: 60.35,19.05 60.93,18.47 60.96,18.41 60.77,18.61 60.77,18.62 60.64,18.75 60.35,19.05
TP_P66_PCIRST_L_R: length 1.8
  TOP w0.127: 72.58,33.86 72.71,33.99 73,34.29 72.42,33.71 U3D1.C17 72.58,33.85 72.58,33.86
TRDY_L: length 38.8
  TOP w0.127: 57.15,92.71 J3B2.A36 78.73,92.71 79.64,91.81 80.38,91.81 81.29,92.71 J4B1.A36
TRST: length 33.8
  LAYER_6 w0.127: 59.69,137.16 72.39,137.16 72.76,136.79 75.3,136.79 75.84,136.26 77.84,136.26 78.75,137.16 92.71,137.16

## Copper pours and planes (outline as drawn)
GND on LAYER_7_P, LAYER_9_P: 3.81,146.69 3.81,3.81 118.11,3.81 118.11,146.69
GND on LAYER_8: 21.62,121.34 21.62,109.83 44.15,109.83 44.15,121.34
P5V on LAYER_4_P: 3.81,146.69 3.81,3.81 118.11,3.81 118.11,146.69
+3_3V on LAYER_2_P: 3.81,146.69 3.81,3.81 118.11,3.81 118.11,146.69

## Text on the board
TOP: TOP | BOT
Ref Des/Assembly Top: LIB DRIVEN | BACKDRILL
User.45: FIGURE | SIZE | 14.0 | 38.0 | 40.0 | 96.0 | 98.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 12 | 360 | 368 | 6
